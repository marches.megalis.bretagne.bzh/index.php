Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:Off], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:On], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: GROUPE SCOLAIRE ST JULIEN DCE - 25-03-26.ifc
Time: 2026-03-26T00:29:41
Author: BIDART\ben17
Organization: Structural Designer
Written by: IFC Parser Version: 3.13.2
Made in: Tekla Structures 2023 Service Pack 10, IFC Export Version: 4.0.0.0 May 31 2024

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: 3266*145, POUTRE
In: Undefined
Description: 3266*145; Material: CONCRETE/C25/30
Pset_BeamCommon - LoadBearing: no; Reference: Po0(?)
Tekla Commun - Niveau bas: +0.000; Niveau haut: +3.266; Repère de pièce: Po0(?); Repère d'assemblage: Po0(?); Phase: 1; Classe: 6; Matériau: C25/30; Profil: 3266*145; Nom: POUTRE
Tekla Quantités - Poids: 4884.4 kg; Volume: 1.9 m3; Surface supérieure totale: 0.6 m2; Surface par tonne: 6.2 m2; Surface nette: 30.3 m2; Hauteur: 3266 mm; Largeur: 145 mm; Longueur: 4297.5 mm
BaseQuantities - Length: 4297.5 mm; OuterSurfaceArea: 30.2647 m2; NetVolume: 2.03517 m3; NetWeight: 4884.4 kg

# IfcBeam: 3270*145, MUR
In: Undefined
Description: 3270*145; Material: TIMBER/BOIS_Existant
Pset_BeamCommon - LoadBearing: no; Reference: Po0(?)
Tekla Commun - Niveau bas: +0.000; Niveau haut: +3.267; Repère de pièce: Po0(?); Repère d'assemblage: Po0(?); Phase: 1; Classe: 6; Matériau: BOIS_Existant; Profil: 3270*145; Nom: MUR
Tekla Quantités - Poids: 0 kg; Volume: 2.4 m3; Surface supérieure totale: 0 m2; Surface par tonne: 0 m2; Surface nette: 35.5 m2; Hauteur: 3267.3 mm; Largeur: 145 mm; Longueur: 5214 mm
BaseQuantities - Length: 5213.98 mm; OuterSurfaceArea: 35.5494 m2; NetVolume: 2.40091 m3; NetWeight: 0 kg

# IfcBeam: 3290*145, MUR
In: Undefined
Description: 3290*145; Material: TIMBER/BOIS_Existant
Pset_BeamCommon - LoadBearing: no; Reference: Po0(?)
Tekla Commun - Niveau bas: +0.000; Niveau haut: +3.290; Repère de pièce: Po0(?); Repère d'assemblage: Po0(?); Phase: 1; Classe: 6; Matériau: BOIS_Existant; Profil: 3290*145; Nom: MUR
Tekla Quantités - Poids: 0 kg; Volume: 3 m3; Surface supérieure totale: 0.8 m2; Surface par tonne: 0 m2; Surface nette: 42.4 m2; Hauteur: 3290 mm; Largeur: 145 mm; Longueur: 6032 mm
BaseQuantities - Length: 6032.04 mm; OuterSurfaceArea: 42.3942 m2; NetVolume: 2.87758 m3; NetWeight: 0 kg

# IfcBeam: 3400*145 (2)
In: Undefined
Description: 3400*145; Material: TIMBER/BOIS_Existant
Pset_BeamCommon - LoadBearing: no; Reference: Po0(?)
Tekla Commun - Niveau bas: +0.000; Niveau haut: +3.400; Repère de pièce: Po0(?); Repère d'assemblage: Po0(?); Phase: 1; Classe: 6; Matériau: BOIS_Existant; Profil: 3400*145; Nom: MUR
Tekla Quantités - Poids: 0 kg; Surface par tonne: 0 m2; Hauteur: 3400 mm; Largeur: 145 mm
BaseQuantities - NetWeight: 0 kg
Name | Volume (m3) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
MUR | 3 | 0.8 | 44.3 | 6106.8 | 6106.79 | 44.2831 | 3.01065
MUR | 5 | 1.5 | 73.3 | 10197.9 | 10197.9 | 73.2893 | 5.02758

# IfcBeam: 3425*145 (3)
In: Undefined
Description: 3425*145; Material: TIMBER/BOIS_Existant
Pset_BeamCommon - LoadBearing: no; Reference: Po0(?)
Tekla Commun - Niveau bas: +0.000; Niveau haut: +3.425; Repère de pièce: Po0(?); Repère d'assemblage: Po0(?); Phase: 1; Classe: 6; Matériau: BOIS_Existant; Profil: 3425*145; Nom: MUR
Tekla Quantités - Poids: 0 kg; Surface par tonne: 0 m2; Hauteur: 3425 mm; Largeur: 145 mm
BaseQuantities - NetWeight: 0 kg
Name | Volume (m3) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
MUR | 1 | 0.3 | 14.7 | 1919.5 | 1919.54 | 14.6988 | 0.953293
MUR | 0.6 | 0.2 | 11 | 1408.5 | 1408.46 | 11.0496 | 0.699475
MUR | 1.7 | 0.5 | 24.9 | 3351.3 | 3351.35 | 24.9219 | 1.66436

# IfcBeam: 3525*145, MUR
In: Undefined
Description: 3525*145; Material: TIMBER/BOIS_Existant
Pset_BeamCommon - LoadBearing: no; Reference: Po0(?)
Tekla Commun - Niveau bas: -0.000; Niveau haut: +3.525; Repère de pièce: Po0(?); Repère d'assemblage: Po0(?); Phase: 1; Classe: 6; Matériau: BOIS_Existant; Profil: 3525*145; Nom: MUR
Tekla Quantités - Poids: 0 kg; Volume: 2.1 m3; Surface supérieure totale: 0.6 m2; Surface par tonne: 0 m2; Surface nette: 31.3 m2; Hauteur: 3525 mm; Largeur: 145 mm; Longueur: 4121.8 mm
BaseQuantities - Length: 4121.78 mm; OuterSurfaceArea: 31.2761 m2; NetVolume: 2.10675 m3; NetWeight: 0 kg

# IfcBeam: 3735*145, MUR
In: Undefined
Description: 3735*145; Material: TIMBER/BOIS_Existant
Pset_BeamCommon - LoadBearing: no; Reference: Po0(?)
Tekla Commun - Niveau bas: +0.000; Niveau haut: +3.735; Repère de pièce: Po0(?); Repère d'assemblage: Po0(?); Phase: 1; Classe: 6; Matériau: BOIS_Existant; Profil: 3735*145; Nom: MUR
Tekla Quantités - Poids: 0 kg; Volume: 2.2 m3; Surface supérieure totale: 0.6 m2; Surface par tonne: 0 m2; Surface nette: 32.7 m2; Hauteur: 3735 mm; Largeur: 145 mm; Longueur: 4080.1 mm
BaseQuantities - Length: 4080.06 mm; OuterSurfaceArea: 32.7444 m2; NetVolume: 2.20966 m3; NetWeight: 0 kg

# IfcBeam: 3736*145 (3)
In: Undefined
Description: 3736*145; Material: CONCRETE/C25/30
Pset_BeamCommon - LoadBearing: no; Reference: Po0(?)
Tekla Commun - Niveau bas: +0.000; Repère de pièce: Po0(?); Repère d'assemblage: Po0(?); Phase: 1; Classe: 6; Matériau: C25/30; Profil: 3736*145; Nom: POUTRE
Tekla Quantités - Surface supérieure totale: 0 m2; Largeur: 145 mm
Name | Niveau haut | Poids (kg) | Volume (m3) | Surface par tonne (m2) | Surface nette (m2) | Hauteur (mm) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x POUTRE | +3.643 | 3427.8 | 1.4 | 6.3 | 21.5 | 3643.5 | 3000 | 3000 | 21.5346 | 1.42825 | 3427.81
POUTRE | +3.736 | 6726.2 | 2.8 | 6.2 | 41.8 | 3736 | 6838 | 6838.01 | 41.8047 | 2.80258 | 6726.18

# IfcBeam: 3915*145 (2)
In: Undefined
Description: 3915*145; Material: TIMBER/BOIS_Existant
Pset_BeamCommon - LoadBearing: no; Reference: Po0(?)
Tekla Commun - Niveau bas: +0.000; Niveau haut: +3.915; Repère de pièce: Po0(?); Repère d'assemblage: Po0(?); Phase: 1; Classe: 6; Matériau: BOIS_Existant; Profil: 3915*145; Nom: MUR
Tekla Quantités - Poids: 0 kg; Surface par tonne: 0 m2; Hauteur: 3915 mm; Largeur: 145 mm
BaseQuantities - NetWeight: 0 kg
Name | Volume (m3) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
MUR | 1.9 | 0.5 | 28.3 | 3351.3 | 3351.35 | 28.3483 | 1.90248
MUR | 3.7 | 1 | 54.8 | 6603.9 | 6603.95 | 54.7594 | 3.7489

# IfcBeam: 3916*145 (4)
In: Undefined
Description: 3916*145; Material: TIMBER/BOIS_Existant
Tekla Commun - Niveau bas: +0.000; Niveau haut: +3.916; Repère de pièce: Po0(?); Repère d'assemblage: Po0(?); Phase: 1; Classe: 6; Matériau: BOIS_Existant; Profil: 3916*145; Nom: MUR
Tekla Quantités - Poids: 0 kg; Surface par tonne: 0 m2; Hauteur: 3916 mm; Largeur: 145 mm
Pset_BeamCommon - LoadBearing: no; Reference: Po0(?)
BaseQuantities - NetWeight: 0 kg
Name | Volume (m3) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
MUR | 0.6 | 0.1 | 9.2 | 994.9 | 994.913 | 9.21632 | 0.564932
MUR | 0.6 | 0.1 | 9.2 | 995.1 | 995.087 | 9.21773 | 0.56503
MUR | 14.9 | 3.8 | 214.4 | 26253.2 | 26253.2 | 214.364 | 14.9071
MUR | 10 | 2.6 | 144.4 | 17643.7 | 17643.7 | 144.438 | 10.0185

# IfcBeam: 5000*145 (4)
In: Undefined
Description: 5000*145
Pset_BeamCommon - LoadBearing: no; Reference: Po0(?)
Tekla Commun - Niveau bas: +0.000; Repère de pièce: Po0(?); Repère d'assemblage: Po0(?); Phase: 1; Classe: 6; Profil: 5000*145
Tekla Quantités - Largeur: 145 mm
Name | Material | Niveau haut | Matériau | Nom | Poids (kg) | Volume (m3) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Hauteur (mm) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
MUR | TIMBER/BOIS_Existant | +5.000 | BOIS_Existant | MUR | 0 | 3.1 | 0.6 | 0 | 45.3 | 5000 | 4263.2 | 4263.19 | 45.3182 | 3.09081 | 0
POUTRE | CONCRETE/C25/30 | +4.640 | C25/30 | POUTRE | 3513.8 | 1.4 | 0 | 6.3 | 22.1 | 4640.1 | 2642.7 | 2642.71 | 22.1366 | 1.4641 | 3513.84
POUTRE | CONCRETE/C25/30 | +5.000 | C25/30 | POUTRE | 7586 | 3.2 | 0.6 | 6.2 | 46.3 | 5000 | 4359.8 | 4359.76 | 46.3119 | 3.16082 | 7585.98
MUR | TIMBER/BOIS_Existant | +4.640 | BOIS_Existant | MUR | 0 | 1.4 | 0 | 0 | 23.1 | 4640.1 | 2800.7 | 2800.71 | 23.1053 | 1.53174 | 0

# IfcBeam: 5090*145, MUR
In: Undefined
Description: 5090*145; Material: TIMBER/BOIS_Existant
Pset_BeamCommon - LoadBearing: no; Reference: Po0(?)
Tekla Commun - Niveau bas: -0.000; Niveau haut: +5.090; Repère de pièce: Po0(?); Repère d'assemblage: Po0(?); Phase: 1; Classe: 6; Matériau: BOIS_Existant; Profil: 5090*145; Nom: MUR
Tekla Quantités - Poids: 0 kg; Volume: 9.3 m3; Surface supérieure totale: 1.8 m2; Surface par tonne: 0 m2; Surface nette: 133 m2; Hauteur: 5090 mm; Largeur: 145 mm; Longueur: 12559.2 mm
BaseQuantities - Length: 12559.2 mm; OuterSurfaceArea: 132.97 m2; NetVolume: 9.26929 m3; NetWeight: 0 kg

# IfcBeam: 5500*145 (4)
In: Undefined
Description: 5500*145; Material: TIMBER/BOIS_Existant
Pset_BeamCommon - LoadBearing: no; Reference: Po0(?)
Tekla Commun - Repère de pièce: Po0(?); Repère d'assemblage: Po0(?); Phase: 1; Classe: 6; Matériau: BOIS_Existant; Profil: 5500*145; Nom: MUR
Tekla Quantités - Poids: 0 kg; Surface supérieure totale: 0 m2; Surface par tonne: 0 m2; Largeur: 145 mm
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Volume (m3) | Surface nette (m2) | Hauteur (mm) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
MUR | +0.000 | +5.072 | 6.4 | 92.2 | 5071.5 | 9834.5 | 9834.49 | 92.161 | 6.39016
MUR | +0.000 | +5.072 | 6.4 | 92.3 | 5071.5 | 9848.5 | 9848.48 | 92.273 | 6.39801
MUR | -0.000 | +5.073 | 5.4 | 78.6 | 5073.1 | 8345.3 | 8345.25 | 78.6177 | 5.43862
MUR | +0.000 | +5.073 | 5.4 | 78.6 | 5073.1 | 8345 | 8344.98 | 78.6154 | 5.43852

# IfcBeam: PL100*100, CVT
In: Undefined
Description: PL100*100; Material: TIMBER/C24 - BMASSIF
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Niveau bas: +2.955; Niveau haut: +3.055; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 12; Matériau: C24 - BMASSIF; Profil: PL100*100; Nom: CVT
Tekla Quantités - Poids: 10.7 kg; Volume: 0 m3; Surface supérieure totale: 0.3 m2; Surface par tonne: 97.1 m2; Surface nette: 1 m2; Hauteur: 100 mm; Largeur: 100 mm; Longueur: 2515.2 mm
BaseQuantities - Length: 2515.2 mm; OuterSurfaceArea: 1.02608 m2; NetVolume: 0.025152 m3; NetWeight: 10.5639 kg

# IfcBeam: PL120*120 (9)
In: Undefined
Description: PL120*120; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 9; Matériau: GL24h - BLC; Profil: PL120*120; Nom: CVT
Tekla Quantités - Volume: 0.1 m3; Hauteur: 120 mm; Largeur: 120 mm
Name | Niveau bas | Niveau haut | Poids (kg) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
CVT | +3.231 | +3.351 | 39.7 | 0.8 | 76.5 | 2.9 | 6263.4 | 6263.4 | 3.03523 | 0.090193 | 39.6849
5 x CVT | +3.231 | +3.351 | 60.6 | 1.1 | 76.2 | 4.7 | 9559.5 | 9559.49 | 4.61736 | 0.137657 | 60.5689
CVT | +3.249 | +3.369 | 50.5 | 1 | 76.2 | 3.9 | 7977.3 | 7977.27 | 3.85789 | 0.114873 | 50.544
2 x CVT | +3.239 | +3.359 | 50.5 | 1 | 76.2 | 3.9 | 7977.3 | 7977.27 | 3.85789 | 0.114873 | 50.544

# IfcBeam: PL135*135 (31)
In: Undefined
Description: PL135*135; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 9; Matériau: GL24h - BLC; Profil: PL135*135; Nom: CVT
Tekla Quantités - Hauteur: 135 mm; Largeur: 135 mm
Name | Niveau bas | Niveau haut | Poids (kg) | Volume (m3) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x CVT | +3.224 | +3.359 | 45.6 | 0.1 | 0.8 | 68.1 | 3.1 | 5680.3 | 5680.35 | 3.10384 | 0.103524 | 45.5507
CVT | +3.006 | +4.591 | 33.3 | 0.1 | 0 | 68.4 | 2.3 | 4153.6 | 4153.56 | 2.27937 | 0.0756987 | 33.3074
CVT | +3.006 | +4.591 | 33.2 | 0.1 | 0 | 68.4 | 2.3 | 4135.6 | 4135.6 | 2.26967 | 0.0753713 | 33.1634
CVT | +2.940 | +4.590 | 33.9 | 0.1 | 0 | 68.4 | 2.3 | 4223.9 | 4223.92 | 2.31737 | 0.0769809 | 33.8716
CVT | +4.591 | +4.726 | 146 | 0.3 | 2.4 | 67.6 | 9.8 | 18203.3 | 18203.3 | 9.86623 | 0.331755 | 145.972
CVT | +4.591 | +4.726 | 115.5 | 0.3 | 1.9 | 67.6 | 7.8 | 14397.4 | 14397.4 | 7.81104 | 0.262392 | 115.453
CVT | +4.591 | +4.726 | 148.4 | 0.3 | 2.4 | 67.6 | 10 | 18504.9 | 18504.9 | 10.0291 | 0.337252 | 148.391
CVT | +2.807 | +4.701 | 40.5 | 0.1 | 0 | 68.1 | 2.8 | 5046 | 5046.04 | 2.76131 | 0.091964 | 40.4642
CVT | +2.789 | +4.709 | 53.5 | 0.1 | 0 | 68 | 3.6 | 6669 | 6669 | 3.63771 | 0.121543 | 53.4787
CVT | +2.790 | +4.563 | 47.8 | 0.1 | 0 | 68.1 | 3.3 | 5961.9 | 5961.9 | 3.25588 | 0.108656 | 47.8085
CVT | +2.866 | +4.721 | 40.1 | 0.1 | 0 | 68.1 | 2.7 | 5002.3 | 5002.3 | 2.73769 | 0.091167 | 40.1135
CVT | +2.884 | +4.705 | 49.2 | 0.1 | 0 | 68.1 | 3.3 | 6136 | 6135.99 | 3.34988 | 0.111828 | 49.2045
CVT | +2.884 | +4.728 | 52.5 | 0.1 | 0 | 68 | 3.6 | 6542.5 | 6542.5 | 3.5694 | 0.119237 | 52.4643
CVT | +2.996 | +4.668 | 40.3 | 0.1 | 0 | 68.1 | 2.8 | 5027.7 | 5027.69 | 2.7514 | 0.0916297 | 40.3171
CVT | +3.050 | +4.649 | 30.8 | 0.1 | 0 | 68.4 | 2.1 | 3841.6 | 3841.6 | 2.11091 | 0.0700132 | 30.8058
CVT | +2.853 | +4.665 | 37.2 | 0.1 | 0 | 68.3 | 2.5 | 4641 | 4641.03 | 2.5426 | 0.0845827 | 37.2164
CVT | +4.591 | +4.726 | 41 | 0.1 | 0.6 | 68.1 | 2.8 | 5103.6 | 5103.62 | 2.7924 | 0.0930134 | 40.9259
CVT | +4.591 | +4.726 | 75.3 | 0.2 | 1.3 | 67.8 | 5.1 | 9395.6 | 9395.6 | 5.11007 | 0.171235 | 75.3433
CVT | +2.941 | +4.723 | 41.8 | 0.1 | 0 | 68.1 | 2.9 | 5214.8 | 5214.8 | 2.85244 | 0.0950398 | 41.8175
CVT | +3.216 | +3.351 | 51 | 0.1 | 0.8 | 68.1 | 3.5 | 6359.1 | 6359.09 | 3.47036 | 0.115894 | 50.9935
CVT | +3.216 | +3.352 | 52.3 | 0.1 | 0 | 68 | 3.6 | 6527.8 | 6527.77 | 3.56145 | 0.118969 | 52.3462
CVT | +3.216 | +3.352 | 44.9 | 0.1 | 0 | 68.1 | 3.1 | 5605.2 | 5605.17 | 3.06324 | 0.102154 | 44.9479
CVT | +3.216 | +3.351 | 52.5 | 0.1 | 0.8 | 68 | 3.6 | 6538.3 | 6538.33 | 3.56715 | 0.119161 | 52.4309
CVT | +3.216 | +3.351 | 56.4 | 0.1 | 0.8 | 68 | 3.8 | 7031.9 | 7031.89 | 3.83367 | 0.128156 | 56.3887
CVT | +3.216 | +3.351 | 49 | 0.1 | 0.8 | 68.1 | 3.3 | 6110.2 | 6110.18 | 3.33595 | 0.111358 | 48.9976
CVT | +3.224 | +3.359 | 46.8 | 0.1 | 0.8 | 68.1 | 3.2 | 5833.3 | 5833.27 | 3.18642 | 0.106311 | 46.777
CVT | +3.224 | +3.359 | 48.8 | 0.1 | 0.8 | 68.1 | 3.3 | 6081.8 | 6081.77 | 3.32061 | 0.11084 | 48.7697
CVT | +3.224 | +3.359 | 47.1 | 0.1 | 0.8 | 68.1 | 3.2 | 5869.8 | 5869.8 | 3.20614 | 0.106977 | 47.0699
CVT | +3.224 | +3.359 | 139.1 | 0.3 | 2.3 | 67.6 | 9.4 | 17342.7 | 17342.7 | 9.40153 | 0.316071 | 139.071
CVT | +3.216 | +3.351 | 208.1 | 0.5 | 3.5 | 67.4 | 14.1 | 25952.2 | 25952.2 | 14.0506 | 0.472979 | 208.111

# IfcBeam: PL145*145 (49)
In: Undefined
Description: PL145*145; Material: TIMBER/C24 - BMASSIF
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Matériau: C24 - BMASSIF; Profil: PL145*145
Tekla Quantités - Volume: 0.1 m3; Hauteur: 145 mm; Largeur: 145 mm
Name | Niveau bas | Niveau haut | Classe | Nom | Poids (kg) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
POTEAU | -0.000 | +3.290 | 8 | POTEAU | 29.1 | 0 | 67.1 | 2 | 3290 | 3290 | 1.95025 | 0.0691722 | 29.0523
POTEAU | -0.000 | +3.915 | 8 | POTEAU | 34.6 | 0 | 66.9 | 2.3 | 3915 | 3915 | 2.31275 | 0.0823129 | 34.5714
POTEAU | +0.000 | +3.916 | 10 | POTEAU | 34.6 | 0 | 66.9 | 2.3 | 3916 | 3916 | 2.31333 | 0.082334 | 34.5803
POTEAU | -0.000 | +5.090 | 8 | POTEAU | 44.9 | 0 | 66.6 | 2.9 | 5090 | 5090 | 2.99425 | 0.107017 | 44.9472
POTEAU | -0.000 | +4.817 | 8 | POTEAU | 42.5 | 0 | 66.6 | 2.8 | 4816.7 | 4816.74 | 2.83576 | 0.101272 | 42.5342
2 x POTEAU | +0.000 | +4.817 | 8 | POTEAU | 42.5 | 0 | 66.6 | 2.8 | 4816.7 | 4816.74 | 2.83576 | 0.101272 | 42.5342
POTEAU | +0.000 | +3.420 | 8 | POTEAU | 30.2 | 0 | 67.1 | 2 | 3420 | 3420 | 2.02565 | 0.0719055 | 30.2003
2 x POTEAU | -0.000 | +3.420 | 8 | POTEAU | 30.2 | 0 | 67.1 | 2 | 3420 | 3420 | 2.02565 | 0.0719055 | 30.2003
3 x POTEAU | +0.000 | +3.400 | 8 | POTEAU | 30 | 0 | 67.1 | 2 | 3400 | 3400 | 2.01405 | 0.071485 | 30.0237
POTEAU | -0.000 | +3.266 | 8 | POTEAU | 28.8 | 0 | 67.1 | 2 | 3266 | 3266.01 | 1.93633 | 0.0686678 | 28.8405
2 x POTEAU | +0.000 | +3.270 | 8 | POTEAU | 28.9 | 0 | 67.1 | 2 | 3270 | 3270 | 1.93865 | 0.0687517 | 28.8757
9 x POTEAU | +0.000 | +3.736 | 10 | POTEAU | 33 | 0 | 66.9 | 2.2 | 3736.3 | 3736.27 | 2.20909 | 0.0785552 | 32.9932
5 x POTEAU | -0.000 | +3.736 | 10 | POTEAU | 33 | 0 | 66.9 | 2.2 | 3736.3 | 3736.27 | 2.20909 | 0.0785552 | 32.9932
CVT | -0.040 | +3.704 | 10 | CVT | 38.7 | 0 | 66.8 | 2.6 | 4381.7 | 4381.65 | 2.58341 | 0.0921243 | 38.6922
CVT | -0.040 | +3.704 | 10 | CVT | 39 | 0 | 66.8 | 2.6 | 4405.8 | 4405.78 | 2.5974 | 0.0926315 | 38.9052
CVT | +3.591 | +3.736 | 10 | CVT | 21.9 | 0.3 | 67.6 | 1.5 | 2475.8 | 2475.76 | 1.47799 | 0.0520529 | 21.8622
CVT | +3.591 | +3.736 | 10 | CVT | 22.2 | 0.3 | 67.6 | 1.5 | 2519.5 | 2519.48 | 1.50335 | 0.052972 | 22.2482
2 x CVT | +2.265 | +3.731 | 10 | CVT | 31.4 | 0 | 66.9 | 2.1 | 3554.2 | 3554.19 | 2.10348 | 0.0747269 | 31.3853
2 x CVT | -0.037 | +2.370 | 10 | CVT | 24 | 0 | 67.4 | 1.6 | 2722.6 | 2722.56 | 1.62113 | 0.0572418 | 24.0416
CVT | -0.024 | +2.429 | 10 | CVT | 22.5 | 0 | 67.4 | 1.5 | 2549.6 | 2549.56 | 1.5208 | 0.0536046 | 22.5139
2 x CVT | +2.260 | +2.405 | 10 | CVT | 29.7 | 0.5 | 67.1 | 2 | 3368 | 3367.96 | 1.99546 | 0.0708113 | 29.7407
2 x CVT | +3.591 | +3.736 | 10 | CVT | 30.4 | 0.5 | 67.1 | 2 | 3440.5 | 3440.46 | 2.03751 | 0.0723356 | 30.381
4 x POTEAU | +0.000 | +2.405 | 10 | POTEAU | 21.2 | 0 | 67.6 | 1.5 | 2405 | 2405.01 | 1.43696 | 0.0505654 | 21.2375
POTEAU | +0.000 | +3.736 | 8 | POTEAU | 33 | 0 | 66.9 | 2.2 | 3736.3 | 3736.27 | 2.20909 | 0.0785552 | 32.9932
CVT | -0.021 | +2.427 | 10 | CVT | 22.2 | 0 | 67.6 | 1.5 | 2518.1 | 2518.14 | 1.50257 | 0.0529439 | 22.2364

# IfcBeam: PL145*45 (312)
In: Undefined
Description: PL145*45; Material: TIMBER/C24 - BMASSIF
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 1; Matériau: C24 - BMASSIF; Profil: PL145*45; Nom: POTEAU
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 145 mm; Largeur: 45 mm
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Name | Niveau bas | Niveau haut | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
9 x POTEAU | +0.000 | +3.290 | 9 | 140.1 | 1.3 | 3290 | 3290 | 1.26325 | 0.0214673 | 9.01625
61 x POTEAU | -0.000 | +3.916 | 10.7 | 139.9 | 1.5 | 3916 | 3916 | 1.50113 | 0.0255519 | 10.7318
POTEAU | -0.000 | +3.290 | 9 | 140.1 | 1.3 | 3290 | 3290 | 1.26325 | 0.0214673 | 9.01625
POTEAU | +0.000 | +3.525 | 9.7 | 139.9 | 1.5 | 3525 | 3525 | 1.35255 | 0.0230006 | 9.66026
3 x POTEAU | +0.000 | +2.923 | 8 | 140.3 | 1.1 | 2923.2 | 2923.22 | 1.12388 | 0.019074 | 8.0111
POTEAU | -0.000 | +2.923 | 8 | 140.3 | 1.1 | 2923.2 | 2923.22 | 1.12388 | 0.019074 | 8.0111
POTEAU | -0.000 | +3.032 | 8.3 | 140.3 | 1.3 | 3032.5 | 3032.46 | 1.16538 | 0.0197868 | 8.31046
POTEAU | -0.000 | +3.177 | 8.7 | 140.3 | 1.3 | 3176.5 | 3176.51 | 1.22012 | 0.0207267 | 8.70522
POTEAU | +0.000 | +3.321 | 9 | 140.1 | 1.3 | 3320.6 | 3320.55 | 1.27486 | 0.0216666 | 9.09998
POTEAU | -0.000 | +3.465 | 9.5 | 139.9 | 1.3 | 3464.6 | 3464.6 | 1.3296 | 0.0226065 | 9.49474
14 x POTEAU | -0.000 | +3.736 | 10.2 | 139.9 | 1.5 | 3736.3 | 3736.28 | 1.43284 | 0.0243792 | 10.2393
POTEAU | +0.000 | +3.509 | 9.7 | 139.9 | 1.3 | 3509.1 | 3509.14 | 1.34652 | 0.0228971 | 9.6168
POTEAU | +0.000 | +3.377 | 9.3 | 140.1 | 1.3 | 3377 | 3376.97 | 1.2963 | 0.0220347 | 9.25459
POTEAU | +0.000 | +3.233 | 9 | 140.1 | 1.3 | 3232.9 | 3232.93 | 1.24156 | 0.0210948 | 8.85983
POTEAU | -0.000 | +3.089 | 8.5 | 140.3 | 1.3 | 3088.9 | 3088.88 | 1.18682 | 0.0201549 | 8.46507
20 x POTEAU | +0.000 | +3.915 | 10.7 | 139.9 | 1.5 | 3915 | 3915 | 1.50075 | 0.0255454 | 10.7291
7 x POTEAU | +0.000 | +3.736 | 10.2 | 139.9 | 1.5 | 3736.3 | 3736.28 | 1.43284 | 0.0243792 | 10.2393
8 x POTEAU | -0.000 | +5.000 | 13.7 | 139.6 | 2 | 5000 | 5000.02 | 1.91306 | 0.0326251 | 13.7026
POTEAU | -0.000 | +4.441 | 12.2 | 139.7 | 1.8 | 4440.5 | 4440.54 | 1.70045 | 0.0289745 | 12.1693
2 x POTEAU | -0.000 | +4.069 | 11.1 | 139.7 | 1.6 | 4068.5 | 4068.51 | 1.55908 | 0.026547 | 11.1498
3 x POTEAU | -0.000 | +3.393 | 9.3 | 140.1 | 1.3 | 3392.7 | 3392.67 | 1.30226 | 0.0221371 | 9.2976
2 x POTEAU | -0.000 | +2.959 | 8 | 140.3 | 1.1 | 2959.3 | 2959.35 | 1.1376 | 0.0193097 | 8.11009
POTEAU | +0.000 | +4.268 | 11.7 | 139.7 | 1.6 | 4268.1 | 4268.07 | 1.63492 | 0.0278491 | 11.6966
POTEAU | +0.000 | +3.896 | 10.7 | 139.9 | 1.5 | 3896 | 3896.04 | 1.49355 | 0.0254217 | 10.6771
POTEAU | -0.000 | +3.524 | 9.7 | 139.9 | 1.5 | 3524 | 3524.02 | 1.35218 | 0.0229942 | 9.65757
POTEAU | +0.000 | +3.152 | 8.5 | 140.3 | 1.3 | 3152 | 3152 | 1.21081 | 0.0205668 | 8.63804
9 x POTEAU | -0.000 | +3.266 | 9 | 140.1 | 1.3 | 3266 | 3266 | 1.25413 | 0.0213107 | 8.95048
7 x POTEAU | -0.000 | +5.000 | 13.7 | 139.6 | 2 | 5000 | 5000 | 1.91305 | 0.032625 | 13.7025
5 x POTEAU | -0.000 | +3.425 | 9.3 | 140.1 | 1.3 | 3425 | 3425 | 1.31455 | 0.0223481 | 9.38621
8 x POTEAU | +0.000 | +3.425 | 9.3 | 140.1 | 1.3 | 3425 | 3425 | 1.31455 | 0.0223481 | 9.38621
3 x POTEAU | +0.000 | +3.929 | 10.7 | 139.9 | 1.5 | 3928.9 | 3928.89 | 1.50603 | 0.025636 | 10.7671
POTEAU | -0.000 | +4.040 | 11.1 | 139.7 | 1.5 | 4040.4 | 4040.43 | 1.54841 | 0.0263638 | 11.0728
POTEAU | +0.000 | +4.184 | 11.5 | 139.7 | 1.6 | 4184.5 | 4184.48 | 1.60315 | 0.0273037 | 11.4676
POTEAU | -0.000 | +4.329 | 11.9 | 139.7 | 1.8 | 4328.5 | 4328.53 | 1.65789 | 0.0282436 | 11.8623
POTEAU | -0.000 | +4.473 | 12.2 | 139.7 | 1.8 | 4472.6 | 4472.57 | 1.71263 | 0.0291835 | 12.2571
POTEAU | +0.000 | +4.617 | 12.7 | 139.7 | 1.8 | 4616.6 | 4616.62 | 1.76737 | 0.0301234 | 12.6518
POTEAU | +0.000 | +4.761 | 13 | 139.7 | 1.8 | 4760.7 | 4760.66 | 1.8221 | 0.0310633 | 13.0466
POTEAU | +0.000 | +4.905 | 13.4 | 139.6 | 2 | 4904.7 | 4904.71 | 1.87684 | 0.0320032 | 13.4414
POTEAU | +0.000 | +5.049 | 13.7 | 139.6 | 2 | 5048.8 | 5048.76 | 1.93158 | 0.0329431 | 13.8361
POTEAU | -0.000 | +4.961 | 13.7 | 139.6 | 2 | 4961.1 | 4961.09 | 1.89826 | 0.0323711 | 13.5959
POTEAU | +0.000 | +4.817 | 13.2 | 139.6 | 1.8 | 4817 | 4817.04 | 1.84353 | 0.0314312 | 13.2011
POTEAU | -0.000 | +4.673 | 12.7 | 139.7 | 1.8 | 4673 | 4673 | 1.78879 | 0.0304913 | 12.8063
POTEAU | +0.000 | +4.529 | 12.4 | 139.7 | 1.8 | 4529 | 4528.95 | 1.73405 | 0.0295514 | 12.4116
POTEAU | -0.000 | +4.385 | 11.9 | 139.7 | 1.8 | 4384.9 | 4384.91 | 1.67931 | 0.0286115 | 12.0168
POTEAU | -0.000 | +4.241 | 11.7 | 139.7 | 1.6 | 4240.9 | 4240.86 | 1.62458 | 0.0276716 | 11.6221
POTEAU | -0.000 | +4.097 | 11.1 | 139.7 | 1.6 | 4096.8 | 4096.81 | 1.56984 | 0.0267317 | 11.2273
2 x POTEAU | -0.000 | +3.953 | 10.7 | 139.9 | 1.5 | 3952.8 | 3952.77 | 1.5151 | 0.0257918 | 10.8326
3 x POTEAU | +0.000 | +3.916 | 10.7 | 139.9 | 1.5 | 3916 | 3916 | 1.50113 | 0.0255519 | 10.7318
POTEAU | +0.000 | +3.967 | 10.9 | 139.9 | 1.5 | 3966.8 | 3966.81 | 1.52044 | 0.0258834 | 10.871
POTEAU | +0.000 | +4.111 | 11.3 | 139.7 | 1.6 | 4110.9 | 4110.85 | 1.57517 | 0.0268233 | 11.2658
POTEAU | +0.000 | +4.256 | 11.7 | 139.7 | 1.6 | 4255.7 | 4255.67 | 1.63021 | 0.0277683 | 11.6627
POTEAU | -0.000 | +4.399 | 12.2 | 139.7 | 1.8 | 4398.9 | 4398.94 | 1.68465 | 0.0287031 | 12.0553
POTEAU | -0.000 | +4.543 | 12.4 | 139.7 | 1.8 | 4543 | 4542.99 | 1.73939 | 0.029643 | 12.4501
POTEAU | +0.000 | +4.688 | 12.7 | 139.7 | 1.8 | 4687.8 | 4687.77 | 1.7944 | 0.0305877 | 12.8468
POTEAU | +0.000 | +4.831 | 13.2 | 139.6 | 1.8 | 4831.2 | 4831.21 | 1.84891 | 0.0315236 | 13.2399
POTEAU | -0.000 | +4.964 | 13.7 | 139.6 | 2 | 4964.3 | 4964.32 | 1.89949 | 0.0323922 | 13.6047
POTEAU | -0.000 | +5.035 | 13.7 | 139.6 | 2 | 5034.7 | 5034.71 | 1.92624 | 0.0328515 | 13.7976
POTEAU | -0.000 | +4.891 | 13.4 | 139.6 | 2 | 4890.7 | 4890.67 | 1.8715 | 0.0319116 | 13.4029
POTEAU | -0.000 | +4.747 | 13 | 139.7 | 1.8 | 4746.6 | 4746.62 | 1.81677 | 0.0309717 | 13.0081
POTEAU | -0.000 | +4.603 | 12.7 | 139.7 | 1.8 | 4602.6 | 4602.58 | 1.76203 | 0.0300318 | 12.6134
POTEAU | +0.000 | +4.467 | 12.2 | 139.7 | 1.8 | 4467.2 | 4467.24 | 1.7106 | 0.0291488 | 12.2425
POTEAU | -0.000 | +4.314 | 11.7 | 139.7 | 1.8 | 4314.5 | 4314.48 | 1.65255 | 0.028152 | 11.8238
POTEAU | +0.000 | +4.170 | 11.3 | 139.7 | 1.6 | 4170.4 | 4170.44 | 1.59782 | 0.0272121 | 11.4291
POTEAU | -0.000 | +4.026 | 10.9 | 139.7 | 1.5 | 4026.5 | 4026.46 | 1.5431 | 0.0262726 | 11.0345
23 x POTEAU | +0.000 | +3.400 | 9.3 | 140.1 | 1.3 | 3400 | 3400 | 1.30505 | 0.022185 | 9.3177
POTEAU | +0.000 | +3.095 | 8.5 | 140.3 | 1.3 | 3094.9 | 3094.94 | 1.18913 | 0.0201945 | 8.48169
POTEAU | +0.000 | +3.116 | 8.5 | 140.3 | 1.3 | 3116 | 3116.03 | 1.19714 | 0.0203321 | 8.53948
POTEAU | +0.000 | +3.137 | 8.5 | 140.3 | 1.3 | 3137.1 | 3137.12 | 1.20516 | 0.0204697 | 8.59728
POTEAU | +0.000 | +3.158 | 8.7 | 140.3 | 1.3 | 3158.2 | 3158.21 | 1.21317 | 0.0206073 | 8.65507
POTEAU | +0.000 | +3.179 | 8.7 | 140.3 | 1.3 | 3179.3 | 3179.3 | 1.22118 | 0.0207449 | 8.71287
POTEAU | +0.000 | +3.200 | 8.7 | 140.1 | 1.3 | 3200.4 | 3200.39 | 1.2292 | 0.0208825 | 8.77066
POTEAU | +0.000 | +3.221 | 8.7 | 140.1 | 1.3 | 3221.5 | 3221.48 | 1.23721 | 0.0210201 | 8.82846
POTEAU | +0.000 | +3.243 | 9 | 140.1 | 1.3 | 3242.6 | 3242.57 | 1.24523 | 0.0211577 | 8.88625
POTEAU | +0.000 | +3.401 | 9.3 | 140.1 | 1.3 | 3400.7 | 3400.7 | 1.30532 | 0.0221896 | 9.31961
POTEAU | +0.000 | +3.262 | 9 | 140.1 | 1.3 | 3262.1 | 3262.07 | 1.25264 | 0.021285 | 8.93971
4 x POTEAU | -0.000 | +3.400 | 9.3 | 140.1 | 1.3 | 3400 | 3400 | 1.30505 | 0.022185 | 9.3177
24 x POTEAU | -0.000 | +5.090 | 13.9 | 139.6 | 2 | 5090 | 5089.99 | 1.94725 | 0.0332122 | 13.9491
8 x POTEAU | -0.000 | +3.525 | 9.7 | 139.9 | 1.5 | 3525 | 3525 | 1.35255 | 0.0230006 | 9.66026
POTEAU | -0.000 | +3.956 | 10.7 | 139.9 | 1.5 | 3956.1 | 3956.11 | 1.51637 | 0.0258136 | 10.8417
POTEAU | -0.000 | +4.123 | 11.3 | 139.7 | 1.6 | 4122.5 | 4122.51 | 1.5796 | 0.0268994 | 11.2977
2 x POTEAU | -0.000 | +4.289 | 11.7 | 139.7 | 1.6 | 4288.9 | 4288.9 | 1.64283 | 0.0279851 | 11.7537
2 x POTEAU | +0.000 | +4.591 | 12.7 | 139.7 | 1.8 | 4590.9 | 4590.9 | 1.75759 | 0.0299556 | 12.5813
POTEAU | +0.000 | +4.609 | 12.7 | 139.7 | 1.8 | 4608.7 | 4608.69 | 1.76435 | 0.0300717 | 12.6301
POTEAU | -0.000 | +4.775 | 13.2 | 139.7 | 1.8 | 4775.1 | 4775.09 | 1.82758 | 0.0311574 | 13.0861
POTEAU | +0.000 | +4.941 | 13.4 | 139.6 | 2 | 4941.5 | 4941.48 | 1.89081 | 0.0322431 | 13.5421
2 x POTEAU | +0.000 | +5.063 | 13.9 | 139.6 | 2 | 5063.4 | 5063.36 | 1.93713 | 0.0330384 | 13.8761
2 x POTEAU | +0.000 | +4.761 | 13 | 139.7 | 1.8 | 4761.1 | 4761.08 | 1.82226 | 0.031066 | 13.0477
POTEAU | -0.000 | +4.594 | 12.7 | 139.7 | 1.8 | 4594.1 | 4594.06 | 1.75879 | 0.0299763 | 12.59
POTEAU | -0.000 | +4.428 | 12.2 | 139.7 | 1.8 | 4427.7 | 4427.67 | 1.69556 | 0.0288905 | 12.134
POTEAU | +0.000 | +4.261 | 11.7 | 139.7 | 1.6 | 4261.3 | 4261.27 | 1.63233 | 0.0278048 | 11.678
POTEAU | +0.000 | +4.095 | 11.1 | 139.7 | 1.6 | 4094.9 | 4094.88 | 1.5691 | 0.0267191 | 11.222
POTEAU | +0.000 | +4.067 | 11.1 | 139.7 | 1.6 | 4067.1 | 4067.09 | 1.55854 | 0.0265377 | 11.1458
POTEAU | +0.000 | +4.233 | 11.7 | 139.7 | 1.6 | 4233.5 | 4233.48 | 1.62177 | 0.0276235 | 11.6019
POTEAU | +0.000 | +4.400 | 12.2 | 139.7 | 1.8 | 4399.9 | 4399.87 | 1.685 | 0.0287092 | 12.0579
POTEAU | +0.000 | +4.566 | 12.4 | 139.7 | 1.8 | 4566.3 | 4566.27 | 1.74823 | 0.0297949 | 12.5139
POTEAU | -0.000 | +4.733 | 13 | 139.7 | 1.8 | 4732.7 | 4732.66 | 1.81146 | 0.0308806 | 12.9699
POTEAU | +0.000 | +4.899 | 13.4 | 139.6 | 2 | 4899.1 | 4899.06 | 1.87469 | 0.0319663 | 13.4259
POTEAU | -0.000 | +5.065 | 13.9 | 139.6 | 2 | 5065.4 | 5065.45 | 1.93792 | 0.0330521 | 13.8819
POTEAU | +0.000 | +4.927 | 13.4 | 139.6 | 2 | 4926.9 | 4926.91 | 1.88528 | 0.0321481 | 13.5022
POTEAU | +0.000 | +4.761 | 13 | 139.7 | 1.8 | 4760.5 | 4760.52 | 1.82205 | 0.0310624 | 13.0462
POTEAU | +0.000 | +4.594 | 12.7 | 139.7 | 1.8 | 4594.1 | 4594.13 | 1.75882 | 0.0299767 | 12.5902
POTEAU | -0.000 | +4.428 | 12.2 | 139.7 | 1.8 | 4427.7 | 4427.73 | 1.69559 | 0.0288909 | 12.1342
POTEAU | +0.000 | +4.261 | 11.7 | 139.7 | 1.6 | 4261.3 | 4261.34 | 1.63236 | 0.0278052 | 11.6782
POTEAU | +0.000 | +4.095 | 11.1 | 139.7 | 1.6 | 4094.9 | 4094.94 | 1.56913 | 0.0267195 | 11.2222

# IfcBeam: PL180*180 (4)
In: Undefined
Description: PL180*180; Material: TIMBER/C24 - BMASSIF
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 8; Matériau: C24 - BMASSIF; Profil: PL180*180; Nom: POTEAU
Tekla Quantités - Volume: 0.1 m3; Surface supérieure totale: 0 m2; Hauteur: 180 mm; Largeur: 180 mm
Name | Niveau bas | Niveau haut | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
POTEAU | -0.000 | +3.420 | 46.5 | 54.3 | 2.5 | 3420 | 2.5272 | 0.110808 | 46.5394
POTEAU | -0.000 | +3.290 | 44.8 | 54.4 | 2.5 | 3290 | 2.4336 | 0.106596 | 44.7703
POTEAU | +0.000 | +2.720 | 37 | 54.7 | 2 | 2720 | 2.0232 | 0.088128 | 37.0138
POTEAU | +0.000 | +3.270 | 44.5 | 54.4 | 2.5 | 3270 | 2.4192 | 0.105948 | 44.4982

# IfcBeam: PL180*65 (3)
In: Undefined
Description: PL180*65; Material: TIMBER/C24 - BMASSIF
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 14; Matériau: C24 - BMASSIF; Profil: PL180*65; Nom: PANNE
Tekla Quantités - Poids: 41 kg; Volume: 0.1 m3; Surface supérieure totale: 0 m2; Surface par tonne: 100.3 m2; Surface nette: 4.1 m2; Hauteur: 180 mm; Largeur: 65 mm; Longueur: 8356.3 mm
BaseQuantities - Length: 8356.25 mm; OuterSurfaceArea: 4.09843 m2; NetVolume: 0.0972806 m3; NetWeight: 40.8579 kg
Name | Niveau bas | Niveau haut
PANNE | +2.630 | +2.815
PANNE | +2.535 | +2.719
PANNE | +2.726 | +2.910

# IfcBeam: PL2*8200, CHENEAU
In: Undefined
Description: PL2*8200; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.509; Niveau haut: +2.759; Repère de pièce: CH0(?); Repère d'assemblage: CH0(?); Finition: GALVA/ALU-ZINC; Phase: 1; Classe: 5; Matériau: S235JR; Profil: PL2*8200; Nom: CHENEAU
Tekla Quantités - Poids: 95.5 kg; Volume: 0 m3; Surface supérieure totale: 0.2 m2; Surface par tonne: 127.8 m2; Surface nette: 12.2 m2; Hauteur: 8200 mm; Largeur: 2 mm; Longueur: 732 mm
Pset_BeamCommon - LoadBearing: no; Reference: CH0(?)
BaseQuantities - Length: 732.032 mm; OuterSurfaceArea: 12.2076 m2; NetVolume: 0.0121719 m3; NetWeight: 95.549 kg

# IfcBeam: PL200*200 (5)
In: Undefined
Description: PL200*200; Material: TIMBER/C24 - BMASSIF
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 8; Matériau: C24 - BMASSIF; Profil: PL200*200; Nom: POTEAU
Tekla Quantités - Volume: 0.1 m3; Surface supérieure totale: 0 m2; Hauteur: 200 mm; Largeur: 200 mm
Name | Niveau bas | Niveau haut | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x POTEAU | +0.000 | +3.270 | 54.9 | 49.1 | 2.7 | 3270 | 2.696 | 0.1308 | 54.936
POTEAU | -0.000 | +2.820 | 47.4 | 49.3 | 2.3 | 2820 | 2.336 | 0.1128 | 47.376
POTEAU | +0.000 | +2.720 | 45.7 | 49.4 | 2.3 | 2720 | 2.256 | 0.1088 | 45.696
POTEAU | -0.000 | +3.290 | 55.3 | 49.1 | 2.7 | 3290 | 2.712 | 0.1316 | 55.272

# IfcBeam: PL200*75 (111)
In: Undefined
Description: PL200*75; Material: TIMBER/C24 - BMASSIF
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Matériau: C24 - BMASSIF; Profil: PL200*75
Tekla Quantités - Hauteur: 200 mm; Largeur: 75 mm
Name | Niveau bas | Niveau haut | Classe | Nom | Poids (kg) | Volume (m3) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
PANNE | +2.734 | +2.946 | 14 | PANNE | 43.1 | 0.1 | 0 | 88 | 3.8 | 6838 | 6838.01 | 3.79091 | 0.10257 | 43.0795
2 x PANNE | +4.579 | +4.792 | 14 | PANNE | 112.1 | 0.3 | 0 | 87.6 | 9.8 | 17788.7 | 17788.7 | 9.81381 | 0.266831 | 112.069
2 x PANNE | +4.310 | +4.522 | 14 | PANNE | 112.1 | 0.3 | 0 | 87.6 | 9.8 | 17788.7 | 17788.7 | 9.81381 | 0.266831 | 112.069
2 x PANNE | +4.040 | +4.253 | 14 | PANNE | 112.1 | 0.3 | 0 | 87.6 | 9.8 | 17788.7 | 17788.7 | 9.81381 | 0.266831 | 112.069
2 x PANNE | +3.771 | +3.984 | 14 | PANNE | 112.1 | 0.3 | 0 | 87.6 | 9.8 | 17788.7 | 17788.7 | 9.81381 | 0.266831 | 112.069
2 x PANNE | +2.306 | +2.731 | 7 | PANNE | 20.4 | 0 | 0 | 88.8 | 1.8 | 3234.1 | 3234.11 | 1.80876 | 0.0485116 | 20.3749
PANNE | +2.716 | +2.925 | 14 | PANNE | 53.5 | 0.1 | 0 | 88 | 4.7 | 8498.8 | 8498.8 | 4.70434 | 0.127482 | 53.5425
PANNE | +2.720 | +2.933 | 14 | PANNE | 52.9 | 0.1 | 0 | 88 | 4.7 | 8391.4 | 8391.4 | 4.64527 | 0.125871 | 52.8658
PANNE | +2.720 | +2.933 | 14 | PANNE | 52.8 | 0.1 | 0 | 88 | 4.7 | 8382.6 | 8382.65 | 4.64046 | 0.12574 | 52.8107
PANNE | +2.751 | +2.956 | 14 | PANNE | 54.3 | 0.1 | 0 | 88 | 4.8 | 8626.1 | 8626.06 | 4.77433 | 0.129391 | 54.3442
PANNE | +3.081 | +3.293 | 14 | PANNE | 43.1 | 0.1 | 0 | 88 | 3.8 | 6838 | 6838.01 | 3.79091 | 0.10257 | 43.0795
PANNE | +3.728 | +3.940 | 14 | PANNE | 84 | 0.2 | 0 | 87.6 | 7.5 | 13328.7 | 13328.7 | 7.36079 | 0.199931 | 83.9708
PANNE | +4.010 | +4.222 | 14 | PANNE | 84 | 0.2 | 0 | 87.6 | 7.5 | 13328.7 | 13328.7 | 7.36079 | 0.199931 | 83.9708
PANNE | +4.293 | +4.505 | 14 | PANNE | 84 | 0.2 | 0 | 87.6 | 7.5 | 13328.7 | 13328.7 | 7.36079 | 0.199931 | 83.9708
PANNE | +4.575 | +4.787 | 14 | PANNE | 84 | 0.2 | 0 | 87.6 | 7.5 | 13328.7 | 13328.7 | 7.36079 | 0.199931 | 83.9708
PANNE | +4.866 | +5.066 | 14 | PANNE | 166.3 | 0.3 | 1.9 | 87.5 | 14.5 | 26398.2 | 26398.2 | 14.549 | 0.395973 | 166.309
PANNE | +4.584 | +4.796 | 14 | PANNE | 166.3 | 0.3 | 0 | 87.5 | 14.5 | 26398.2 | 26398.2 | 14.549 | 0.395973 | 166.309
PANNE | +4.310 | +4.522 | 14 | PANNE | 166.3 | 0.3 | 0 | 87.5 | 14.5 | 26398.2 | 26398.2 | 14.549 | 0.395973 | 166.309
PANNE | +4.036 | +4.248 | 14 | PANNE | 166.3 | 0.3 | 0 | 87.5 | 14.5 | 26398.2 | 26398.2 | 14.549 | 0.395973 | 166.309
PANNE | +3.763 | +3.975 | 14 | PANNE | 166.3 | 0.3 | 0 | 87.5 | 14.5 | 26398.2 | 26398.2 | 14.549 | 0.395973 | 166.309
2 x POUTRE | +2.870 | +4.811 | 13 | POUTRE | 12.2 | 0 | 0 | 89.8 | 1.1 | 1940.8 | 1940.82 | 1.09745 | 0.0291124 | 12.2272
8 x POUTRE | +2.870 | +4.777 | 13 | POUTRE | 11.9 | 0 | 0 | 89.8 | 1.1 | 1906.8 | 1906.83 | 1.07875 | 0.0286024 | 12.013
2 x POUTRE | +2.870 | +3.070 | 13 | POUTRE | 13.4 | 0 | 0.2 | 89.5 | 1.3 | 2122.9 | 2122.88 | 1.19758 | 0.0318431 | 13.3741
2 x POUTRE | +2.877 | +3.077 | 13 | POUTRE | 13.4 | 0 | 0.2 | 89.5 | 1.3 | 2122.9 | 2122.88 | 1.19758 | 0.0318431 | 13.3741
2 x POUTRE | +2.870 | +3.070 | 13 | POUTRE | 11.9 | 0 | 0.1 | 89.8 | 1.1 | 1897.5 | 1897.51 | 1.07363 | 0.0284626 | 11.9543
2 x POUTRE | +2.877 | +3.077 | 13 | POUTRE | 11.9 | 0 | 0.1 | 89.8 | 1.1 | 1897.5 | 1897.51 | 1.07363 | 0.0284626 | 11.9543
2 x POUTRE | +2.870 | +4.817 | 13 | POUTRE | 12.2 | 0 | 0 | 89.7 | 1.1 | 1946.7 | 1946.74 | 1.10071 | 0.0292011 | 12.2644
2 x POUTRE | +2.870 | +4.811 | 13 | POUTRE | 12.2 | 0 | 0 | 89.8 | 1.1 | 1940.7 | 1940.74 | 1.09741 | 0.0291112 | 12.2267
4 x POUTRE | +2.870 | +5.020 | 13 | POUTRE | 13.4 | 0 | 0 | 89.5 | 1.3 | 2150.2 | 2150.21 | 1.21262 | 0.0322532 | 13.5463
2 x POUTRE | +2.870 | +4.721 | 13 | POUTRE | 11.7 | 0 | 0 | 89.8 | 1 | 1851.3 | 1851.27 | 1.0482 | 0.027769 | 11.663
2 x POUTRE | +2.870 | +4.921 | 13 | POUTRE | 13 | 0 | 0 | 89.7 | 1.3 | 2051.3 | 2051.35 | 1.15824 | 0.0307702 | 12.9235
2 x POUTRE | +2.870 | +3.070 | 13 | POUTRE | 28.9 | 0.1 | 0.3 | 88.3 | 2.6 | 4610.2 | 4610.18 | 2.5656 | 0.0691527 | 29.0441
2 x POUTRE | +2.870 | +4.867 | 13 | POUTRE | 12.7 | 0 | 0 | 89.7 | 1.1 | 1996.7 | 1996.74 | 1.12821 | 0.0299511 | 12.5794
4 x POUTRE | +2.870 | +5.020 | 13 | POUTRE | 13.4 | 0 | 0 | 89.5 | 1.3 | 2150.2 | 2150.2 | 1.21261 | 0.032253 | 13.5463
4 x POUTRE | +2.870 | +3.070 | 13 | POUTRE | 15.9 | 0 | 0.2 | 89.2 | 1.5 | 2525.2 | 2525.22 | 1.41887 | 0.0378783 | 15.9089
PANNE | +4.575 | +4.787 | 14 | PANNE | 82.3 | 0.2 | 0 | 87.6 | 7.2 | 13069.5 | 13069.5 | 7.21822 | 0.196042 | 82.3378
PANNE | +4.010 | +4.222 | 14 | PANNE | 82.3 | 0.2 | 0 | 87.6 | 7.2 | 13069.5 | 13069.5 | 7.21822 | 0.196042 | 82.3378
PANNE | +3.728 | +3.940 | 14 | PANNE | 82.3 | 0.2 | 0 | 87.6 | 7.2 | 13069.5 | 13069.5 | 7.21822 | 0.196042 | 82.3378
PANNE | +4.293 | +4.505 | 14 | PANNE | 82.3 | 0.2 | 0 | 87.6 | 7.2 | 13069.5 | 13069.5 | 7.21822 | 0.196042 | 82.3378
8 x POUTRE | +2.870 | +3.070 | 13 | POUTRE | 25.2 | 0.1 | 0.3 | 88.5 | 2.2 | 3992.2 | 3992.19 | 2.2257 | 0.0598828 | 25.1508
3 x POUTRE | +2.870 | +3.070 | 13 | POUTRE | 29.5 | 0.1 | 0.3 | 88.3 | 2.6 | 4675.8 | 4675.78 | 2.60168 | 0.0701368 | 29.4574
23 x POUTRE | +0.000 | +3.140 | 10 | POUTRE | 19.8 | 0 | 0 | 88.8 | 1.8 | 3140 | 3139.99 | 1.757 | 0.0470999 | 19.782
POUTRE | +0.000 | +3.300 | 10 | POUTRE | 20.8 | 0 | 0 | 88.7 | 1.8 | 3300.4 | 3300.39 | 1.84522 | 0.0495059 | 20.7925
POUTRE | +0.000 | +3.140 | 10 | POUTRE | 19.8 | 0 | 0 | 88.8 | 1.8 | 3140 | 3140 | 1.757 | 0.0470999 | 19.782
PANNE | +4.866 | +5.066 | 14 | PANNE | 112.1 | 0.3 | 1.3 | 87.6 | 9.8 | 17788.7 | 17788.7 | 9.81381 | 0.266831 | 112.069
2 x POUTRE | +2.870 | +3.070 | 13 | POUTRE | 28.9 | 0.1 | 0.3 | 88.3 | 2.6 | 4605.1 | 4605.07 | 2.56279 | 0.069076 | 29.0119
POUTRE | +2.870 | +3.070 | 13 | POUTRE | 26.3 | 0.1 | 0.3 | 88.3 | 2.3 | 4175.8 | 4175.78 | 2.32668 | 0.0626368 | 26.3074

# IfcBeam: PL225*120 (9)
In: Undefined
Description: PL225*120; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Matériau: GL24h - BLC; Profil: PL225*120
Tekla Quantités - Hauteur: 225 mm; Largeur: 120 mm
Name | Niveau bas | Niveau haut | Classe | Nom | Poids (kg) | Volume (m3) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x CVT | +2.870 | +2.990 | 9 | CVT | 127.7 | 0.3 | 2.4 | 58.5 | 7.5 | 10752.6 | 10752.6 | 7.47331 | 0.290321 | 127.741
2 x CVT | +2.870 | +2.990 | 9 | CVT | 117.9 | 0.3 | 2.2 | 58.5 | 6.9 | 9926.7 | 9926.68 | 6.90341 | 0.26802 | 117.929
CVT | +2.660 | +2.780 | 9 | CVT | 119.5 | 0.3 | 2.3 | 58.5 | 6.9 | 10060 | 10060 | 6.9954 | 0.27162 | 119.513
CVT | +2.910 | +3.030 | 9 | CVT | 268 | 0.6 | 5.1 | 58.3 | 15.6 | 22561 | 22561 | 15.6211 | 0.609147 | 268.025
CVT | +2.910 | +3.030 | 9 | CVT | 268.3 | 0.6 | 5.1 | 58.3 | 15.6 | 22585.7 | 22585.7 | 15.6381 | 0.609814 | 268.318
2 x POUTRE | +1.924 | +3.046 | 8 | POUTRE | 16.5 | 0 | 0 | 61.4 | 1 | 1386.2 | 1386.22 | 1.01049 | 0.0374279 | 16.4683

# IfcBeam: PL225*135 (10)
In: Undefined
Description: PL225*135; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 9; Matériau: GL24h - BLC; Profil: PL225*135; Nom: CVT
Tekla Quantités - Hauteur: 225 mm; Largeur: 135 mm
Name | Niveau bas | Niveau haut | Poids (kg) | Volume (m3) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
CVT | +2.805 | +2.940 | 191 | 0.3 | 3.2 | 54.2 | 10.4 | 14292.4 | 14292.4 | 10.3513 | 0.434132 | 191.018
CVT | +2.895 | +3.030 | 191 | 0.3 | 3.2 | 54.2 | 10.4 | 14292.4 | 14292.4 | 10.3513 | 0.434131 | 191.018
CVT | +3.224 | +3.359 | 233.9 | 0.5 | 3.9 | 54.1 | 12.7 | 17498.7 | 17498.7 | 12.6598 | 0.531524 | 233.871
CVT | +3.224 | +3.359 | 233.9 | 0.5 | 3.9 | 54.1 | 12.7 | 17498.7 | 17498.8 | 12.6599 | 0.531525 | 233.871
2 x CVT | +3.216 | +3.351 | 348.9 | 0.8 | 5.9 | 54 | 18.9 | 26108.2 | 26108.2 | 18.8586 | 0.793036 | 348.936
CVT | +3.216 | +3.351 | 127.8 | 0.3 | 2.2 | 54.3 | 6.9 | 9559.5 | 9559.49 | 6.94358 | 0.29037 | 127.763
CVT | +3.216 | +3.351 | 153.2 | 0.3 | 2.6 | 54.3 | 8.4 | 11464 | 11464 | 8.31482 | 0.348219 | 153.216
CVT | +3.224 | +3.359 | 107.7 | 0.2 | 1.8 | 54.4 | 5.9 | 8055 | 8054.96 | 5.86032 | 0.244669 | 107.655
CVT | +3.224 | +3.359 | 107.7 | 0.2 | 1.8 | 54.4 | 5.9 | 8055.3 | 8055.26 | 5.86054 | 0.244679 | 107.659

# IfcBeam: PL225*90 (14)
In: Undefined
Description: PL225*90
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Profil: PL225*90
Tekla Quantités - Hauteur: 225 mm; Largeur: 90 mm
Name | Material | Niveau bas | Niveau haut | Classe | Matériau | Nom | Poids (kg) | Volume (m3) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x CVT | TIMBER/GL24h - BLC | +2.211 | +4.103 | 3 | GL24h - BLC | CVT | 25.1 | 0.1 | 0 | 72.3 | 1.8 | 2817.8 | 2817.78 | 1.8157 | 0.0570601 | 25.1064
2 x CVT | TIMBER/GL24h - BLC | +3.845 | +4.070 | 3 | GL24h - BLC | CVT | 41 | 0.1 | 0.5 | 71.7 | 2.9 | 4606.9 | 4606.93 | 2.94287 | 0.0932903 | 41.0477
4 x CVT | TIMBER/GL24h - BLC | +2.097 | +4.036 | 3 | GL24h - BLC | CVT | 22.2 | 0.1 | 0 | 72.5 | 1.6 | 2486.1 | 2486.1 | 1.60674 | 0.0503435 | 22.1511
2 x CVT | TIMBER/GL24h - BLC | +3.902 | +4.127 | 3 | GL24h - BLC | CVT | 45.3 | 0.1 | 0.5 | 71.7 | 3.2 | 5086.1 | 5086.08 | 3.24473 | 0.102993 | 45.3169
POUTRE | TIMBER/C24 - BMASSIF | +3.845 | +4.596 | 13 | C24 - BMASSIF | POUTRE | 6.4 | 0 | 0 | 80.4 | 0.5 | 751.3 | 751.307 | 0.513824 | 0.015214 | 6.38987
POUTRE | TIMBER/C24 - BMASSIF | +3.899 | +4.486 | 13 | C24 - BMASSIF | POUTRE | 5 | 0 | 0 | 82.2 | 0.5 | 587.2 | 587.152 | 0.410406 | 0.0118898 | 4.99373

# IfcBeam: PL250*75 (11)
In: Undefined
Description: PL250*75
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 14; Profil: PL250*75
Tekla Quantités - Hauteur: 250 mm; Largeur: 75 mm
Name | Material | Niveau bas | Niveau haut | Matériau | Nom | Poids (kg) | Volume (m3) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x PANNE | TIMBER/C24 - BMASSIF | +4.213 | +4.474 | C24 - BMASSIF | PANNE | 64.2 | 0.2 | 0 | 83.1 | 5.3 | 8158 | 8158 | 5.3402 | 0.152962 | 64.2442
2 x PANNE | TIMBER/C24 - BMASSIF | +3.675 | +3.936 | C24 - BMASSIF | PANNE | 64.2 | 0.2 | 0 | 83.1 | 5.3 | 8158 | 8158 | 5.3402 | 0.152962 | 64.2442
2 x PANNE | TIMBER/C24 - BMASSIF | +3.944 | +4.205 | C24 - BMASSIF | PANNE | 64.2 | 0.2 | 0 | 83.1 | 5.3 | 8158 | 8158 | 5.3402 | 0.152962 | 64.2442
2 x PANNE | TIMBER/C24 - BMASSIF | +4.483 | +4.744 | C24 - BMASSIF | PANNE | 64.2 | 0.2 | 0 | 83.1 | 5.3 | 8158 | 8158 | 5.3402 | 0.152962 | 64.2442
CVT | TIMBER/GL24h - BLC | +3.690 | +5.021 | GL24h - BLC | CVT | 33.7 | 0.1 | 0 | 79.9 | 2.7 | 4081.3 | 4081.31 | 2.69035 | 0.0765245 | 33.6708
CVT | TIMBER/GL24h - BLC | +3.675 | +5.021 | GL24h - BLC | CVT | 34.1 | 0.1 | 0 | 79.9 | 2.7 | 4136.8 | 4136.81 | 2.72642 | 0.0775651 | 34.1287
PANNE | TIMBER/C24 - BMASSIF | +4.762 | +5.012 | C24 - BMASSIF | PANNE | 64.2 | 0.2 | 0.6 | 83.1 | 5.3 | 8158 | 8158 | 5.3402 | 0.152962 | 64.2442

# IfcBeam: PL270*90 (9)
In: Undefined
Description: PL270*90; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Matériau: GL24h - BLC; Profil: PL270*90
Tekla Quantités - Hauteur: 270 mm; Largeur: 90 mm
Name | Niveau bas | Niveau haut | Classe | Nom | Poids (kg) | Volume (m3) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x ARBA | +3.321 | +4.763 | 3 | ARBA | 54 | 0.1 | 0 | 68.1 | 3.7 | 5054.1 | 5054.13 | 3.68757 | 0.122815 | 54.0388
4 x POTEAU | +0.000 | +3.648 | 10 | POTEAU | 39 | 0.1 | 0 | 68.6 | 2.7 | 3648.4 | 3648.44 | 2.67547 | 0.088657 | 39.0091
CVT | +2.870 | +3.140 | 12 | CVT | 104.6 | 0.2 | 0.8 | 67.8 | 7.2 | 9781.7 | 9781.68 | 7.09141 | 0.237695 | 104.586
CVT | +2.870 | +3.140 | 12 | CVT | 102.9 | 0.2 | 0.8 | 67.8 | 6.9 | 9623.7 | 9623.68 | 6.97765 | 0.233855 | 102.896
CVT | +2.870 | +3.140 | 12 | CVT | 110.2 | 0.3 | 0.8 | 67.8 | 7.5 | 10302.6 | 10302.6 | 7.46649 | 0.250354 | 110.156

# IfcBeam: PL275*75 (14)
In: Undefined
Description: PL275*75; Material: TIMBER/C24 - BMASSIF
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 14; Matériau: C24 - BMASSIF; Profil: PL275*75; Nom: PANNE
Tekla Quantités - Surface supérieure totale: 0 m2; Hauteur: 275 mm; Largeur: 75 mm
Name | Niveau bas | Niveau haut | Poids (kg) | Volume (m3) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
PANNE | +3.620 | +3.902 | 97.7 | 0.2 | 81.2 | 7.8 | 11282.9 | 11282.9 | 7.93929 | 0.23271 | 97.7382
PANNE | +3.623 | +3.905 | 97.8 | 0.2 | 81.2 | 7.8 | 11290.1 | 11290.1 | 7.94433 | 0.232859 | 97.8006
PANNE | +3.864 | +4.129 | 122.2 | 0.3 | 81.2 | 9.8 | 14101.8 | 14101.8 | 9.91252 | 0.29085 | 122.157
PANNE | +3.874 | +4.147 | 123.2 | 0.3 | 81.2 | 10 | 14225.5 | 14225.5 | 9.99909 | 0.293401 | 123.228
PANNE | +3.265 | +3.538 | 99 | 0.2 | 81.2 | 8 | 11424.4 | 11424.4 | 8.03833 | 0.235628 | 98.9639
PANNE | +4.482 | +4.756 | 148.4 | 0.3 | 81.2 | 12 | 17123 | 17123 | 12.0273 | 0.353162 | 148.328
PANNE | +4.081 | +4.363 | 109.5 | 0.3 | 81.2 | 8.9 | 12637.6 | 12637.6 | 8.88756 | 0.26065 | 109.473
PANNE | +3.165 | +3.447 | 86.1 | 0.2 | 81.3 | 6.9 | 9942.6 | 9942.65 | 7.0011 | 0.205067 | 86.1282
PANNE | +4.083 | +4.365 | 109.5 | 0.3 | 81.2 | 8.9 | 12644.4 | 12644.4 | 8.89235 | 0.260791 | 109.532
PANNE | +3.157 | +3.439 | 85.9 | 0.2 | 81.3 | 6.9 | 9921.4 | 9921.4 | 6.98623 | 0.204629 | 85.9442
PANNE | +4.539 | +4.821 | 121.1 | 0.3 | 81.2 | 9.8 | 13985.1 | 13985.1 | 9.83079 | 0.288442 | 121.146
PANNE | +3.280 | +3.545 | 99.2 | 0.2 | 81.2 | 8 | 11456.1 | 11456.1 | 8.06049 | 0.236281 | 99.2381
PANNE | +4.448 | +4.713 | 146.6 | 0.3 | 81.2 | 12 | 16924.7 | 16924.7 | 11.8885 | 0.349072 | 146.61
PANNE | +4.546 | +4.828 | 121.3 | 0.3 | 81.2 | 9.8 | 14006 | 14006 | 9.84542 | 0.288873 | 121.327

# IfcBeam: PL300*75 (22)
In: Undefined
Description: PL300*75; Material: TIMBER/C24 - BMASSIF
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 14; Matériau: C24 - BMASSIF; Profil: PL300*75; Nom: PANNE
Tekla Quantités - Hauteur: 300 mm; Largeur: 75 mm
Name | Niveau bas | Niveau haut | Poids (kg) | Volume (m3) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
PANNE | +3.913 | +4.222 | 68.1 | 0.2 | 0 | 79.9 | 5.5 | 7208 | 7208.01 | 5.45101 | 0.16218 | 68.1157
PANNE | +4.195 | +4.505 | 68.1 | 0.2 | 0 | 79.9 | 5.5 | 7208 | 7208.01 | 5.45101 | 0.16218 | 68.1157
PANNE | +4.478 | +4.787 | 68.1 | 0.2 | 0 | 79.9 | 5.5 | 7208 | 7208.01 | 5.45101 | 0.16218 | 68.1157
PANNE | +3.939 | +4.248 | 68.1 | 0.2 | 0 | 79.9 | 5.5 | 7208 | 7208.01 | 5.45101 | 0.16218 | 68.1157
PANNE | +4.213 | +4.522 | 68.1 | 0.2 | 0 | 79.9 | 5.5 | 7208 | 7208.01 | 5.45101 | 0.16218 | 68.1157
PANNE | +4.487 | +4.796 | 68.1 | 0.2 | 0 | 79.9 | 5.5 | 7208 | 7208.01 | 5.45101 | 0.16218 | 68.1157
PANNE | +3.631 | +3.940 | 68.1 | 0.2 | 0 | 79.9 | 5.5 | 7208 | 7208.01 | 5.45101 | 0.16218 | 68.1157
PANNE | +4.766 | +5.066 | 68.1 | 0.2 | 0.5 | 79.9 | 5.5 | 7208 | 7208.01 | 5.45101 | 0.16218 | 68.1157
PANNE | +3.665 | +3.975 | 68.1 | 0.2 | 0 | 79.9 | 5.5 | 7208 | 7208.01 | 5.45101 | 0.16218 | 68.1157
PANNE | +2.900 | +3.203 | 151 | 0.3 | 0 | 79.7 | 12 | 15979.7 | 15979.7 | 12.0298 | 0.359543 | 151.008
PANNE | +2.845 | +3.148 | 198.3 | 0.5 | 0 | 79.7 | 15.8 | 20984.5 | 20984.5 | 15.7834 | 0.472152 | 198.304
PANNE | +2.956 | +3.259 | 138.7 | 0.3 | 0 | 79.7 | 11 | 14672.2 | 14672.2 | 11.0491 | 0.330124 | 138.652
PANNE | +2.914 | +3.216 | 65.4 | 0.2 | 0 | 80.1 | 5.1 | 6915.5 | 6915.47 | 5.2316 | 0.155598 | 65.3512
PANNE | +2.872 | +3.175 | 74.1 | 0.2 | 0 | 79.9 | 5.9 | 7838.7 | 7838.74 | 5.92406 | 0.176372 | 74.0761
PANNE | +2.830 | +3.133 | 82.8 | 0.2 | 0 | 79.9 | 6.7 | 8762 | 8762.02 | 6.61651 | 0.197145 | 82.801
PANNE | +2.956 | +3.258 | 57.2 | 0.1 | 0 | 80.1 | 4.7 | 6049.1 | 6049.14 | 4.58186 | 0.136106 | 57.1644
PANNE | +2.788 | +3.091 | 91.5 | 0.2 | 0 | 79.9 | 7.3 | 9687.8 | 9687.79 | 7.31084 | 0.217975 | 91.5496
PANNE | +2.789 | +3.092 | 213.2 | 0.5 | 0 | 79.7 | 17 | 22560.6 | 22560.6 | 16.9654 | 0.507612 | 213.197
PANNE | +2.989 | +3.291 | 137.8 | 0.3 | 0 | 79.7 | 11 | 14582.4 | 14582.4 | 10.9818 | 0.328104 | 137.804
PANNE | +2.954 | +3.256 | 137.8 | 0.3 | 0 | 79.7 | 11 | 14582.4 | 14582.4 | 10.9818 | 0.328104 | 137.804
PANNE | +3.024 | +3.326 | 137.8 | 0.3 | 0 | 79.7 | 11 | 14582.4 | 14582.4 | 10.9818 | 0.328104 | 137.804
PANNE | +2.919 | +3.221 | 137.8 | 0.3 | 0 | 79.7 | 11 | 14582.4 | 14582.4 | 10.9818 | 0.328104 | 137.804

# IfcBeam: PL320*90 (6)
In: Undefined
Description: PL320*90; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Matériau: GL24h - BLC; Profil: PL320*90
Tekla Quantités - Volume: 0.1 m3; Surface supérieure totale: 0 m2; Hauteur: 320 mm; Largeur: 90 mm
Name | Niveau bas | Niveau haut | Classe | Nom | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x POTEAU | +0.000 | +3.679 | 10 | POTEAU | 46.6 | 65.9 | 3.1 | 3679.5 | 3679.49 | 3.07478 | 0.105969 | 46.6265
2 x POTEAU | +0.000 | +3.679 | 10 | POTEAU | 46.6 | 65.9 | 3.1 | 3679.5 | 3679.48 | 3.07478 | 0.105969 | 46.6264
CVT | +3.289 | +4.762 | 3 | CVT | 55.2 | 65.8 | 3.6 | 4356.4 | 4356.44 | 3.62988 | 0.125466 | 55.2048
CVT | +3.322 | +4.762 | 3 | CVT | 53.7 | 65.8 | 3.5 | 4234.8 | 4234.77 | 3.53012 | 0.121962 | 53.6631

# IfcBeam: PL360*90 (4)
In: Undefined
Description: PL360*90
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Niveau bas: +2.825; Niveau haut: +3.185; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 12; Profil: PL360*90; Nom: CVT
Tekla Quantités - Volume: 0.2 m3; Hauteur: 360 mm; Largeur: 90 mm
Name | Material | Matériau | Poids (kg) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x CVT | TIMBER/C24 - BMASSIF | C24 - BMASSIF | 84 | 0.6 | 66.9 | 5.6 | 6174.6 | 6174.64 | 5.62198 | 0.200058 | 84.0245
2 x CVT | TIMBER/GL24h - BLC | GL24h - BLC | 85.5 | 0.5 | 63.9 | 5.5 | 5997.1 | 5997.14 | 5.46222 | 0.194307 | 85.4952

# IfcBeam: PL380*140 (3)
In: Undefined
Description: PL380*140; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Niveau bas: +2.830; Niveau haut: +3.337; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 5; Matériau: GL24h - BLC; Profil: PL380*140; Nom: POUTRE
Tekla Quantités - Poids: 95.8 kg; Volume: 0.2 m3; Surface supérieure totale: 0 m2; Surface par tonne: 45.5 m2; Surface nette: 4.4 m2; Hauteur: 380 mm; Largeur: 140 mm; Longueur: 4092 mm
BaseQuantities - Length: 4092.02 mm; OuterSurfaceArea: 4.3621 m2; NetVolume: 0.217696 m3; NetWeight: 95.7861 kg

# IfcBeam: PL396*135 (8)
In: Undefined
Description: PL396*135; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 5; Matériau: GL24h - BLC; Profil: PL396*135; Nom: POUTRE
Tekla Quantités - Surface supérieure totale: 0 m2; Hauteur: 396 mm; Largeur: 135 mm
Name | Niveau bas | Niveau haut | Poids (kg) | Volume (m3) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
POUTRE | +2.660 | +3.180 | 64.4 | 0.1 | 46.8 | 2.9 | 2735.8 | 2735.79 | 3.01233 | 0.146256 | 64.3524
POUTRE | +2.688 | +3.180 | 49.8 | 0.1 | 47.3 | 2.5 | 2115.8 | 2115.79 | 2.35389 | 0.11311 | 49.7686
4 x POUTRE | +2.688 | +3.264 | 93.3 | 0.2 | 46.3 | 4.3 | 3965.8 | 3965.79 | 4.31859 | 0.212011 | 93.285
POUTRE | +2.688 | +3.269 | 96.1 | 0.2 | 46.3 | 4.4 | 4085.9 | 4085.92 | 4.44617 | 0.218433 | 96.1106
POUTRE | +2.688 | +3.257 | 146.2 | 0.3 | 45.9 | 6.7 | 6216.1 | 6216.08 | 6.70839 | 0.332311 | 146.217

# IfcBeam: PL40*200 (32)
In: Undefined
Description: PL40*200; Material: TIMBER/C24 - BMASSIF
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 2; Matériau: C24 - BMASSIF; Profil: PL40*200; Nom: FP
Tekla Quantités - Surface par tonne: 143.1 m2; Hauteur: 200 mm; Largeur: 40 mm
Name | Niveau bas | Niveau haut | Poids (kg) | Volume (m3) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
14 x FP | +3.359 | +3.559 | 58.8 | 0.1 | 0.8 | 8.4 | 17498.7 | 8.4154 | 0.13999 | 58.7958
17 x FP | +3.351 | +3.551 | 87.7 | 0.2 | 1 | 12.5 | 26108.2 | 12.5479 | 0.208866 | 87.7235
FP | +3.359 | +3.559 | 58.8 | 0.1 | 0.6 | 8.4 | 17498.7 | 8.4154 | 0.13999 | 58.7958

# IfcBeam: PL400*100, POUTRE
In: Undefined
Description: PL400*100; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Niveau bas: +2.870; Niveau haut: +3.270; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 4; Matériau: GL24h - BLC; Profil: PL400*100; Nom: POUTRE
Tekla Quantités - Poids: 56.3 kg; Volume: 0.1 m3; Surface supérieure totale: 0.3 m2; Surface par tonne: 58.2 m2; Surface nette: 3.3 m2; Hauteur: 400 mm; Largeur: 100 mm; Longueur: 3200 mm
BaseQuantities - Length: 3200 mm; OuterSurfaceArea: 3.28 m2; NetVolume: 0.128 m3; NetWeight: 56.32 kg

# IfcBeam: PL400*120 (15)
In: Undefined
Description: PL400*120; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 3; Matériau: GL24h - BLC; Profil: PL400*120; Nom: POUTRE
Tekla Quantités - Surface supérieure totale: 0 m2; Hauteur: 400 mm; Largeur: 120 mm
Name | Niveau bas | Niveau haut | Poids (kg) | Volume (m3) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x POUTRE | +2.716 | +4.872 | 77.9 | 0.2 | 50.5 | 3.9 | 3771.4 | 3771.36 | 3.93598 | 0.177125 | 77.935
2 x POUTRE | +2.751 | +4.777 | 63.9 | 0.1 | 50.7 | 3.2 | 3094.2 | 3094.2 | 3.24474 | 0.145328 | 63.9441
POUTRE | +3.047 | +4.777 | 49.4 | 0.1 | 51.2 | 2.5 | 2337.7 | 2337.68 | 2.52718 | 0.112209 | 49.3718
POUTRE | +2.981 | +4.777 | 51.7 | 0.1 | 51.1 | 2.6 | 2447.1 | 2447.11 | 2.64099 | 0.117461 | 51.6829
POUTRE | +2.751 | +4.800 | 108.6 | 0.2 | 50.7 | 5.5 | 5500.9 | 5500.85 | 5.50399 | 0.246925 | 108.647
POUTRE | +2.716 | +4.850 | 121.9 | 0.3 | 50.2 | 6.1 | 5980 | 5979.98 | 6.1246 | 0.277049 | 121.902
POUTRE | +2.716 | +4.830 | 120.7 | 0.3 | 50.3 | 6.1 | 5928.8 | 5928.77 | 6.0662 | 0.274304 | 120.694
POUTRE | +2.751 | +4.974 | 121.7 | 0.3 | 50.3 | 6.1 | 5979.6 | 5979.58 | 6.11655 | 0.276626 | 121.716
2 x POUTRE | +2.720 | +5.020 | 111.4 | 0.3 | 50.2 | 5.6 | 5394 | 5393.98 | 5.59288 | 0.253285 | 111.445
2 x POUTRE | +2.720 | +5.020 | 111.4 | 0.3 | 50.2 | 5.6 | 5393.1 | 5393.14 | 5.59202 | 0.253245 | 111.428
POUTRE | +3.083 | +4.872 | 58.1 | 0.1 | 50.9 | 2.9 | 2751.4 | 2751.36 | 2.95741 | 0.132065 | 58.1086

# IfcBeam: PL429*135 (3)
In: Undefined
Description: PL429*135; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Matériau: GL24h - BLC; Profil: PL429*135; Nom: POUTRE
Tekla Quantités - Hauteur: 429 mm; Largeur: 135 mm
Name | Niveau bas | Niveau haut | Classe | Poids (kg) | Volume (m3) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
POUTRE | +2.251 | +2.680 | 4 | 76.4 | 0.2 | 0.5 | 45.8 | 3.5 | 3000 | 3000 | 3.49983 | 0.173745 | 76.4478
2 x POUTRE | +2.655 | +3.262 | 5 | 129.1 | 0.3 | 0 | 45.2 | 5.9 | 5067.2 | 5067.25 | 5.83168 | 0.29347 | 129.127

# IfcBeam: PL500*120 (4)
In: Undefined
Description: PL500*120; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Niveau bas: +2.790; Niveau haut: +3.290; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 4; Matériau: GL24h - BLC; Profil: PL500*120; Nom: POUTRE
Tekla Quantités - Hauteur: 500 mm; Largeur: 120 mm
Name | Poids (kg) | Volume (m3) | Surface supérieure totale (m2) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
POUTRE | 130.6 | 0.3 | 0.6 | 47.9 | 6.3 | 4945.6 | 4945.6 | 6.25254 | 0.296736 | 130.564
POUTRE | 115.1 | 0.3 | 0.5 | 47.9 | 5.5 | 4359.5 | 4359.54 | 5.52583 | 0.261573 | 115.092
POUTRE | 132.8 | 0.3 | 0.6 | 47.9 | 6.3 | 5031.8 | 5031.75 | 6.35937 | 0.301905 | 132.838
POUTRE | 222.3 | 0.5 | 1 | 47.5 | 10.6 | 8420.4 | 8420.36 | 10.5612 | 0.505221 | 222.297

# IfcBeam: PL600*100, POUTRE
In: Undefined
Description: PL600*100; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Niveau bas: +2.825; Niveau haut: +3.425; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 4; Matériau: GL24h - BLC; Profil: PL600*100; Nom: POUTRE
Tekla Quantités - Poids: 133 kg; Volume: 0.3 m3; Surface supérieure totale: 0.5 m2; Surface par tonne: 54 m2; Surface nette: 7.2 m2; Hauteur: 600 mm; Largeur: 100 mm; Longueur: 5036.3 mm
BaseQuantities - Length: 5036.26 mm; OuterSurfaceArea: 7.17076 m2; NetVolume: 0.302176 m3; NetWeight: 132.957 kg

# IfcBeam: PL700*100, POUTRE
In: Undefined
Description: PL700*100; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Niveau bas: +2.200; Niveau haut: +3.027; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 5; Matériau: GL24h - BLC; Profil: PL700*100; Nom: POUTRE
Tekla Quantités - Poids: 126 kg; Volume: 0.3 m3; Surface supérieure totale: 0 m2; Surface par tonne: 53.1 m2; Surface nette: 6.7 m2; Hauteur: 700 mm; Largeur: 100 mm; Longueur: 4092 mm
BaseQuantities - Length: 4092.02 mm; OuterSurfaceArea: 6.68724 m2; NetVolume: 0.286442 m3; NetWeight: 126.034 kg

# IfcBeam: PL80*80 (107)
In: Undefined
Description: PL80*80; Material: TIMBER/C24 - BMASSIF
