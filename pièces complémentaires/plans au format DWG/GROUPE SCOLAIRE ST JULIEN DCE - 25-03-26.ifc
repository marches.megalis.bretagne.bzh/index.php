Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcBeam: PL80*80 (107)
Pset_BeamCommon - LoadBearing: no
Tekla Commun - Phase: 1; Classe: 12; Matériau: C24 - BMASSIF; Profil: PL80*80
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 80 mm; Largeur: 80 mm
Name | Reference = Repère de pièce = Repère d'assemblage | Niveau bas | Niveau haut | Nom | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x CVT | A0(?) | +3.838 | +5.001 | CVT | 12.4 | 120.1 | 1.5 | 4648.3 | 4648.28 | 1.50025 | 0.029749 | 12.4946
2 x CVT | A0(?) | +3.804 | +5.001 | CVT | 13 | 120 | 1.5 | 4796.9 | 4796.89 | 1.54781 | 0.0307001 | 12.894
CVT | A0(?) | +3.795 | +4.164 | CVT | 6.9 | 120.9 | 0.8 | 2552.8 | 2552.79 | 0.829691 | 0.0163378 | 6.86189
CVT | A0(?) | +3.795 | +4.164 | CVT | 7.2 | 120.9 | 0.8 | 2673.4 | 2673.43 | 0.868296 | 0.0171099 | 7.18617
CVT | A0(?) | +3.830 | +4.190 | CVT | 6.9 | 120.9 | 0.8 | 2535.9 | 2535.94 | 0.824299 | 0.01623 | 6.81659
CVT | A0(?) | +3.821 | +4.190 | CVT | 7.2 | 120.9 | 0.8 | 2673.4 | 2673.43 | 0.868296 | 0.0171099 | 7.18617
2 x CVT | A0(?) | +3.781 | +4.147 | CVT | 7.8 | 120.7 | 0.8 | 2901.5 | 2901.5 | 0.941281 | 0.0185696 | 7.79924
CVT | A0(?) | +3.791 | +4.935 | CVT | 10.7 | 120.1 | 1.3 | 3993.8 | 3993.83 | 1.29083 | 0.0255605 | 10.7354
2 x CVT | A0(?) | +3.805 | +4.070 | CVT | 7.5 | 120.9 | 0.8 | 2791.8 | 2791.81 | 0.90618 | 0.0178676 | 7.50439
CVT | A0(?) | +3.816 | +4.935 | CVT | 10.5 | 120.3 | 1.3 | 3900.9 | 3900.89 | 1.26108 | 0.0249657 | 10.4856
2 x ENTRETOISE | E0(?) | +3.388 | +3.864 | ENTRETOISE | 9 | 120.5 | 1.1 | 3387 | 3387.04 | 1.09665 | 0.0216771 | 9.10437
2 x ENTRETOISE | E0(?) | +3.776 | +4.654 | ENTRETOISE | 4.1 | 122.1 | 0.5 | 1539.6 | 1539.58 | 0.505464 | 0.00985329 | 4.13838
2 x ENTRETOISE | E0(?) | +3.389 | +3.863 | ENTRETOISE | 5.6 | 121.4 | 0.8 | 2067.5 | 2067.52 | 0.674407 | 0.0132321 | 5.5575
3 x ENTRETOISE | E0(?) | +3.767 | +4.610 | ENTRETOISE | 3.5 | 122.7 | 0.5 | 1290.9 | 1290.88 | 0.425883 | 0.00826166 | 3.4699
2 x ENTRETOISE | E0(?) | +3.400 | +3.854 | ENTRETOISE | 4.6 | 121.8 | 0.6 | 1707.1 | 1707.05 | 0.559057 | 0.0109251 | 4.58856
2 x ENTRETOISE | E0(?) | +3.400 | +3.854 | ENTRETOISE | 4.5 | 121.8 | 0.6 | 1692.3 | 1692.3 | 0.554336 | 0.0108307 | 4.5489
2 x ENTRETOISE | E0(?) | +3.400 | +3.854 | ENTRETOISE | 4.6 | 121.8 | 0.6 | 1702.5 | 1702.54 | 0.557614 | 0.0108963 | 4.57644
ENTRETOISE | E0(?) | +3.280 | +3.835 | ENTRETOISE | 4.6 | 121.8 | 0.6 | 1710.3 | 1710.34 | 0.560109 | 0.0109462 | 4.5974
ENTRETOISE | E0(?) | +3.280 | +3.835 | ENTRETOISE | 4.6 | 121.8 | 0.6 | 1711.8 | 1711.81 | 0.560581 | 0.0109556 | 4.60136
ENTRETOISE | E0(?) | +3.295 | +3.820 | ENTRETOISE | 4.1 | 122.1 | 0.5 | 1555.4 | 1555.42 | 0.510534 | 0.00995468 | 4.18097
ENTRETOISE | E0(?) | +3.295 | +3.820 | ENTRETOISE | 4.1 | 122.1 | 0.5 | 1576.6 | 1576.62 | 0.517319 | 0.0100904 | 4.23796
ENTRETOISE | E0(?) | +3.735 | +4.725 | ENTRETOISE | 6.4 | 121.1 | 0.8 | 2335.6 | 2335.64 | 0.760203 | 0.0149481 | 6.27819
2 x ENTRETOISE | E0(?) | +3.750 | +4.725 | ENTRETOISE | 6.2 | 121.1 | 0.6 | 2298.1 | 2298.14 | 0.748203 | 0.0147081 | 6.17739
2 x ENTRETOISE | E0(?) | +3.278 | +3.838 | ENTRETOISE | 7.2 | 120.9 | 0.8 | 2633.4 | 2633.4 | 0.855489 | 0.0168538 | 7.07859
ENTRETOISE | E0(?) | +3.288 | +3.817 | ENTRETOISE | 4.1 | 122.1 | 0.5 | 1527.2 | 1527.18 | 0.501497 | 0.00977394 | 4.10505
ENTRETOISE | E0(?) | +3.288 | +3.817 | ENTRETOISE | 4.5 | 122 | 0.5 | 1638 | 1638 | 0.53696 | 0.0104832 | 4.40295
3 x ENTRETOISE | E0(?) | +3.733 | +4.732 | ENTRETOISE | 6.4 | 121.1 | 0.8 | 2360.6 | 2360.64 | 0.768203 | 0.0151081 | 6.34539
ENTRETOISE | E0(?) | +3.287 | +3.818 | ENTRETOISE | 4.5 | 121.8 | 0.5 | 1663.9 | 1663.92 | 0.545256 | 0.0106491 | 4.47263
ENTRETOISE | E0(?) | +3.287 | +3.818 | ENTRETOISE | 4.5 | 121.8 | 0.5 | 1663.9 | 1663.93 | 0.545256 | 0.0106491 | 4.47263
ENTRETOISE | E0(?) | +3.285 | +3.821 | ENTRETOISE | 6.9 | 120.9 | 0.8 | 2536.6 | 2536.59 | 0.824508 | 0.0162342 | 6.81835
ENTRETOISE | E0(?) | +3.285 | +3.821 | ENTRETOISE | 7.2 | 120.9 | 0.8 | 2676.4 | 2676.4 | 0.869249 | 0.017129 | 7.19417
ENTRETOISE | E0(?) | +3.796 | +4.163 | ENTRETOISE | 6.2 | 121.1 | 0.8 | 2310.2 | 2310.23 | 0.752074 | 0.0147855 | 6.2099
ENTRETOISE | E0(?) | +3.796 | +4.163 | ENTRETOISE | 6.2 | 121.1 | 0.6 | 2275.9 | 2275.85 | 0.741072 | 0.0145654 | 6.11749
2 x ENTRETOISE | E0(?) | +3.796 | +4.163 | ENTRETOISE | 7.5 | 120.9 | 0.8 | 2788 | 2787.96 | 0.904946 | 0.0178429 | 7.49403
2 x ENTRETOISE | E0(?) | +3.795 | +4.163 | ENTRETOISE | 6.7 | 120.9 | 0.8 | 2484.8 | 2484.85 | 0.807951 | 0.015903 | 6.67927
ENTRETOISE | E0(?) | +3.796 | +4.163 | ENTRETOISE | 5 | 121.6 | 0.6 | 1840.5 | 1840.48 | 0.601753 | 0.0117791 | 4.9472
ENTRETOISE | E0(?) | +3.796 | +4.163 | ENTRETOISE | 5.1 | 121.4 | 0.6 | 1904.7 | 1904.73 | 0.622312 | 0.0121902 | 5.1199
ENTRETOISE | E0(?) | +3.821 | +4.164 | ENTRETOISE | 6.4 | 120.9 | 0.8 | 2427.5 | 2427.5 | 0.789601 | 0.015536 | 6.52513
ENTRETOISE | E0(?) | +3.821 | +4.164 | ENTRETOISE | 6.7 | 120.9 | 0.8 | 2461.3 | 2461.28 | 0.800411 | 0.0157522 | 6.61593
ENTRETOISE | E0(?) | +3.822 | +4.163 | ENTRETOISE | 6.4 | 120.9 | 0.8 | 2420.7 | 2420.7 | 0.787423 | 0.0154925 | 6.50683
ENTRETOISE | E0(?) | +3.822 | +4.163 | ENTRETOISE | 6.4 | 120.9 | 0.8 | 2420.7 | 2420.69 | 0.787421 | 0.0154924 | 6.50682
6 x ENTRETOISE | E0(?) | +4.077 | +5.001 | ENTRETOISE | 9.7 | 120.3 | 1.3 | 3624.6 | 3624.55 | 1.17266 | 0.0231971 | 9.7428
ENTRETOISE | E0(?) | +3.844 | +4.118 | ENTRETOISE | 5.6 | 121.4 | 0.6 | 2126.1 | 2126.15 | 0.693167 | 0.0136073 | 5.71508
ENTRETOISE | E0(?) | +3.844 | +4.118 | ENTRETOISE | 6 | 121.1 | 0.6 | 2240.5 | 2240.49 | 0.729756 | 0.0143391 | 6.02243
4 x ENTRETOISE | E0(?) | +4.031 | +5.000 | ENTRETOISE | 9 | 120.5 | 1.1 | 3339.8 | 3339.75 | 1.08152 | 0.0213744 | 8.97725
2 x ENTRETOISE | E0(?) | +3.844 | +4.118 | ENTRETOISE | 6 | 121.1 | 0.6 | 2246.3 | 2246.32 | 0.731623 | 0.0143765 | 6.03812
ENTRETOISE | E0(?) | +3.844 | +4.117 | ENTRETOISE | 6.2 | 121.1 | 0.8 | 2307.3 | 2307.32 | 0.751141 | 0.0147668 | 6.20207
ENTRETOISE | E0(?) | +3.845 | +4.117 | ENTRETOISE | 6.2 | 121.1 | 0.8 | 2307.3 | 2307.32 | 0.751141 | 0.0147668 | 6.20207
2 x ENTRETOISE | E0(?) | +3.844 | +4.118 | ENTRETOISE | 6.4 | 120.9 | 0.8 | 2405.4 | 2405.45 | 0.782544 | 0.0153949 | 6.46585
ENTRETOISE | E0(?) | +3.830 | +4.195 | ENTRETOISE | 6.2 | 121.1 | 0.6 | 2257.6 | 2257.6 | 0.735231 | 0.0144486 | 6.06842
ENTRETOISE | E0(?) | +3.829 | +4.195 | ENTRETOISE | 6.4 | 121.1 | 0.8 | 2365.6 | 2365.59 | 0.769789 | 0.0151398 | 6.35871
4 x ENTRETOISE | E0(?) | +4.108 | +5.000 | ENTRETOISE | 8.3 | 120.7 | 1 | 3050.1 | 3050.1 | 0.988832 | 0.0195206 | 8.19867
2 x ENTRETOISE | E0(?) | +3.829 | +4.195 | ENTRETOISE | 6.4 | 121.1 | 0.8 | 2371.1 | 2371.12 | 0.771558 | 0.0151752 | 6.37357
2 x ENTRETOISE | E0(?) | +3.830 | +4.195 | ENTRETOISE | 6.4 | 120.9 | 0.8 | 2429 | 2428.98 | 0.790074 | 0.0155455 | 6.5291
2 x ENTRETOISE | E0(?) | +3.829 | +4.195 | ENTRETOISE | 6.9 | 120.9 | 0.8 | 2522.4 | 2522.38 | 0.819963 | 0.0161433 | 6.78017
ENTRETOISE | E0(?) | +3.822 | +4.189 | ENTRETOISE | 6.2 | 121.1 | 0.8 | 2310.2 | 2310.23 | 0.752074 | 0.0147855 | 6.2099
ENTRETOISE | E0(?) | +3.822 | +4.189 | ENTRETOISE | 6.2 | 121.1 | 0.6 | 2275.9 | 2275.85 | 0.741072 | 0.0145654 | 6.11749
2 x ENTRETOISE | E0(?) | +3.822 | +4.189 | ENTRETOISE | 7.5 | 120.9 | 0.8 | 2788 | 2787.96 | 0.904946 | 0.0178429 | 7.49403
2 x ENTRETOISE | E0(?) | +3.821 | +4.190 | ENTRETOISE | 6.7 | 120.9 | 0.8 | 2484.8 | 2484.85 | 0.807951 | 0.015903 | 6.67927
ENTRETOISE | E0(?) | +3.822 | +4.189 | ENTRETOISE | 5 | 121.6 | 0.6 | 1840.5 | 1840.48 | 0.601753 | 0.0117791 | 4.9472
ENTRETOISE | E0(?) | +3.822 | +4.189 | ENTRETOISE | 5.1 | 121.4 | 0.6 | 1904.7 | 1904.73 | 0.622312 | 0.0121902 | 5.1199
ENTRETOISE | E0(?) | +3.821 | +4.190 | ENTRETOISE | 6.7 | 120.9 | 0.8 | 2478.2 | 2478.24 | 0.805837 | 0.0158607 | 6.66151
ENTRETOISE | E0(?) | +3.821 | +4.190 | ENTRETOISE | 6.9 | 120.9 | 0.8 | 2511.3 | 2511.34 | 0.816429 | 0.0160726 | 6.75048
2 x ENTRETOISE | E0(?) | +3.822 | +4.189 | ENTRETOISE | 6.7 | 120.9 | 0.8 | 2471.6 | 2471.57 | 0.803702 | 0.015818 | 6.64358
6 x ENTRETOISE | E0(?) | +4.103 | +5.001 | ENTRETOISE | 9.3 | 120.3 | 1.1 | 3513.1 | 3513.1 | 1.13699 | 0.0224838 | 9.4432

# IfcBeam: PL90*297 (4)
In: Undefined
Description: PL90*297; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Niveau bas: +0.000; Niveau haut: +3.270; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 8; Matériau: GL24h - BLC; Profil: PL90*297; Nom: POTEAU
Tekla Quantités - Poids: 38.5 kg; Volume: 0.1 m3; Surface supérieure totale: 0 m2; Surface par tonne: 67.1 m2; Surface nette: 2.6 m2; Hauteur: 297 mm; Largeur: 90 mm; Longueur: 3270 mm
BaseQuantities - Length: 3270 mm; OuterSurfaceArea: 2.58444 m2; NetVolume: 0.0874071 m3; NetWeight: 38.4591 kg

# IfcBeam: PL900*120, POUTRE
In: Undefined
Description: PL900*120; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Niveau bas: +2.848; Niveau haut: +3.748; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 4; Matériau: GL24h - BLC; Profil: PL900*120; Nom: POUTRE
Tekla Quantités - Poids: 365.4 kg; Volume: 0.8 m3; Surface supérieure totale: 0.8 m2; Surface par tonne: 43.5 m2; Surface nette: 15.8 m2; Hauteur: 900 mm; Largeur: 120 mm; Longueur: 7688.4 mm
BaseQuantities - Length: 7688.45 mm; OuterSurfaceArea: 15.9004 m2; NetVolume: 0.830352 m3; NetWeight: 365.355 kg

# IfcBeam: PL932*120, POUTRE
In: Undefined
Description: PL932*120; Material: TIMBER/GL24h - BLC
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Niveau bas: +2.770; Niveau haut: +3.702; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 4; Matériau: GL24h - BLC; Profil: PL932*120; Nom: POUTRE
Tekla Quantités - Poids: 1133.9 kg; Volume: 2.6 m3; Surface supérieure totale: 2.8 m2; Surface par tonne: 43 m2; Surface nette: 48.7 m2; Hauteur: 932 mm; Largeur: 120 mm; Longueur: 23042.7 mm
BaseQuantities - Length: 23042.7 mm; OuterSurfaceArea: 48.7056 m2; NetVolume: 2.5771 m3; NetWeight: 1133.92 kg

# IfcColumn: ROND120 (2)
In: Undefined
Description: ROND120; Material: TIMBER/C24 - BMASSIF
Tekla Commun - Niveau bas: +0.000; Niveau haut: +2.531; Repère de pièce: Pt0(?); Repère d'assemblage: Pt0(?); Phase: 1; Classe: 13; Matériau: C24 - BMASSIF; Profil: ROND120; Nom: POTEAU
Tekla Quantités - Poids: 11.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 79.4 m2; Surface nette: 1 m2; Hauteur: 120 mm; Largeur: 120 mm; Longueur: 2531.4 mm
Pset_ColumnCommon - LoadBearing: no; Reference: Pt0(?)
BaseQuantities - OuterSurfaceArea: 0.954321 m2; NetWeight: 11.8273 kg
Name | Length (mm) | NetVolume (m3)
POTEAU | 2531.35 | 0.0281603
POTEAU | 2531.36 | 0.0281604

# IfcElementAssembly (844)
In: Undefined
Name | Poids Assemblage/Elément béton (kg) | Niveau Bas Assemblage/Elément béton | Niveau Haut Assemblage/Elément béton | Position maillage Assemblage/Elément béton | Repère Assemblage/Elément béton | Width (mm)
9 x POTEAU | 9 | +0.000 | +3.290 | 11>/D-E | A0(?) | 45
POTEAU | 29.1 | -0.000 | +3.290 | 11>/D-E | A0(?) | 145
POTEAU | 34.6 | -0.000 | +3.915 | 11>/C-D | A0(?) | 145
POTEAU | 34.6 | +0.000 | +3.916 | 11>/B | A0(?) | 145
CVT | 45.6 | +3.224 | +3.359 | 11>/C-D | A0(?) | 135
MUR | 0 | +0.000 | +3.916 | 11>/B-C | Po0(?) | 145
MUR | 0 | +0.000 | +3.916 | 11>/B | Po0(?) | 145
6 x POTEAU | 10.7 | -0.000 | +3.916 | 11>/B-C | A0(?) | 45
20 x POTEAU | 10.7 | -0.000 | +3.916 | 11>/B | A0(?) | 45
MUR | 0 | +0.000 | +3.915 | 10-11/C-D | Po0(?) | 145
PANNE | 43.1 | +2.734 | +2.946 | 7-10/E> | A0(?) | 75
CHENEAU | 95.5 | +2.509 | +2.759 | 11/D-E> | CH0(?) | 249.412
2 x CVT | 127.7 | +2.870 | +2.990 | 11>/E> | A0(?) | 120
2 x CVT | 117.9 | +2.870 | +2.990 | 11>/E> | A0(?) | 120
2 x POUTRE | 77.9 | +2.716 | +4.872 | 11>/E> | A0(?) | 120
2 x POUTRE | 63.9 | +2.751 | +4.777 | 11>/E> | A0(?) | 120
4 x CVT | 25.1 | +2.211 | +4.103 | 7-8/E> | A0(?) | 90
2 x CVT | 41 | +3.845 | +4.070 | 11>/B-D | A0(?) | 90
2 x CVT | 22.2 | +2.097 | +4.036 | 11>/B-C | A0(?) | 90
CVT | 119.5 | +2.660 | +2.780 | 11>/E> | A0(?) | 120
CVT | 268 | +2.910 | +3.030 | 11>/D-E> | A0(?) | 120
CVT | 191 | +2.805 | +2.940 | 11>/E> | A0(?) | 135
CVT | 268.3 | +2.910 | +3.030 | 11>/C-E> | A0(?) | 120
CVT | 191 | +2.895 | +3.030 | 11>/D-E | A0(?) | 135
POTEAU | 9 | -0.000 | +3.290 | 11>/D-E | A0(?) | 45
POTEAU | 9.7 | +0.000 | +3.525 | 11>/D-E | A0(?) | 45
POTEAU | 8 | +0.000 | +2.923 | 7-8/E> | A0(?) | 45
POTEAU | 8 | -0.000 | +2.923 | 7-8/E> | A0(?) | 45
POTEAU | 8.3 | -0.000 | +3.032 | 7-8/E> | A0(?) | 45
POTEAU | 8.7 | -0.000 | +3.177 | 7-8/E> | A0(?) | 45
POTEAU | 9 | +0.000 | +3.321 | 7-8/E> | A0(?) | 45
POTEAU | 9.5 | -0.000 | +3.465 | 7-8/E> | A0(?) | 45
2 x POTEAU | 10.2 | -0.000 | +3.736 | 7-8/E> | A0(?) | 45
POTEAU | 10.2 | -0.000 | +3.736 | 8/E> | A0(?) | 45
4 x POTEAU | 10.2 | -0.000 | +3.736 | 8-9/E> | A0(?) | 45
POTEAU | 10.2 | -0.000 | +3.736 | 9/E> | A0(?) | 45
4 x POTEAU | 10.2 | -0.000 | +3.736 | 9-10/E> | A0(?) | 45
POTEAU | 9.7 | +0.000 | +3.509 | 9-10/E> | A0(?) | 45
POTEAU | 9.3 | +0.000 | +3.377 | 9-10/E> | A0(?) | 45
POTEAU | 9 | +0.000 | +3.233 | 9-10/E> | A0(?) | 45
POTEAU | 8.5 | -0.000 | +3.089 | 9-10/E> | A0(?) | 45
2 x POTEAU | 8 | +0.000 | +2.923 | 9-10/E> | A0(?) | 45
10 x POTEAU | 10.7 | +0.000 | +3.915 | 11>/C-D | A0(?) | 45
3 x POTEAU | 10.7 | +0.000 | +3.915 | 11/C-D | A0(?) | 45
3 x POTEAU | 10.2 | +0.000 | +3.736 | 11/D | A0(?) | 45
4 x POTEAU | 10.2 | +0.000 | +3.736 | 11/D-E | A0(?) | 45
POTEAU | 13.7 | -0.000 | +5.000 | 11/D-E | A0(?) | 45
POTEAU | 13.7 | -0.000 | +5.000 | 11/E | A0(?) | 45
13 x POTEAU | 13.7 | -0.000 | +5.000 | 11/E> | A0(?) | 45
POTEAU | 12.2 | -0.000 | +4.441 | 11>/E> | A0(?) | 45
2 x POTEAU | 11.1 | -0.000 | +4.069 | 11>/E> | A0(?) | 45
3 x POTEAU | 9.3 | -0.000 | +3.393 | 11>/E> | A0(?) | 45
2 x POTEAU | 8 | -0.000 | +2.959 | 11>/E> | A0(?) | 45
POTEAU | 11.7 | +0.000 | +4.268 | 11>/E> | A0(?) | 45
POTEAU | 10.7 | +0.000 | +3.896 | 11>/E> | A0(?) | 45
POTEAU | 9.7 | -0.000 | +3.524 | 11>/E> | A0(?) | 45
POTEAU | 8.5 | +0.000 | +3.152 | 11>/E> | A0(?) | 45
9 x POTEAU | 9 | -0.000 | +3.266 | 11>/E> | A0(?) | 45
2 x POTEAU | 9.3 | -0.000 | +3.425 | 11/E> | A0(?) | 45
3 x POTEAU | 9.3 | +0.000 | +3.425 | 11/E> | A0(?) | 45
3 x POTEAU | 9.3 | +0.000 | +3.425 | 10-11/E> | A0(?) | 45
2 x POTEAU | 9.3 | +0.000 | +3.425 | 10/E> | A0(?) | 45
3 x POTEAU | 9.3 | -0.000 | +3.425 | 10/E> | A0(?) | 45
3 x POTEAU | 10.7 | +0.000 | +3.929 | 10/E> | A0(?) | 45
POTEAU | 11.1 | -0.000 | +4.040 | 10/E> | A0(?) | 45
POTEAU | 11.5 | +0.000 | +4.184 | 10/E> | A0(?) | 45
POTEAU | 11.9 | -0.000 | +4.329 | 10/E> | A0(?) | 45
POTEAU | 12.2 | -0.000 | +4.473 | 10/E> | A0(?) | 45
POTEAU | 12.7 | +0.000 | +4.617 | 10/E> | A0(?) | 45
POTEAU | 13 | +0.000 | +4.761 | 10/E> | A0(?) | 45
POTEAU | 13.4 | +0.000 | +4.905 | 10/E> | A0(?) | 45
POTEAU | 13.7 | +0.000 | +5.049 | 10/E> | A0(?) | 45
POTEAU | 13.7 | -0.000 | +4.961 | 10/E> | A0(?) | 45
POTEAU | 13.2 | +0.000 | +4.817 | 10/E> | A0(?) | 45
POTEAU | 12.7 | -0.000 | +4.673 | 10/E> | A0(?) | 45
POTEAU | 12.4 | +0.000 | +4.529 | 10/E> | A0(?) | 45
POTEAU | 11.9 | -0.000 | +4.385 | 10/E> | A0(?) | 45
POTEAU | 11.7 | -0.000 | +4.241 | 10/E> | A0(?) | 45
POTEAU | 11.1 | -0.000 | +4.097 | 10/E> | A0(?) | 45
2 x POTEAU | 10.7 | -0.000 | +3.953 | 10/E> | A0(?) | 45
POTEAU | 10.7 | -0.000 | +3.916 | 10/E> | A0(?) | 45
25 x POTEAU | 10.7 | -0.000 | +3.916 | 11>/E> | A0(?) | 45
2 x POTEAU | 10.7 | -0.000 | +3.916 | 10-11/E> | A0(?) | 45
3 x POTEAU | 10.7 | +0.000 | +3.916 | 11>/E> | A0(?) | 45
POTEAU | 10.9 | +0.000 | +3.967 | 11>/E> | A0(?) | 45
POTEAU | 11.3 | +0.000 | +4.111 | 11>/E> | A0(?) | 45
POTEAU | 11.7 | +0.000 | +4.256 | 11>/E> | A0(?) | 45
POTEAU | 12.2 | -0.000 | +4.399 | 11>/E> | A0(?) | 45
POTEAU | 12.4 | -0.000 | +4.543 | 11>/E> | A0(?) | 45
POTEAU | 12.7 | +0.000 | +4.688 | 11>/E> | A0(?) | 45
POTEAU | 13.2 | +0.000 | +4.831 | 11>/E> | A0(?) | 45
POTEAU | 13.7 | -0.000 | +4.964 | 11>/E> | A0(?) | 45
POTEAU | 13.7 | -0.000 | +5.035 | 11>/E> | A0(?) | 45
POTEAU | 13.4 | -0.000 | +4.891 | 11>/E> | A0(?) | 45
POTEAU | 13 | -0.000 | +4.747 | 11>/E> | A0(?) | 45
POTEAU | 12.7 | -0.000 | +4.603 | 11>/E> | A0(?) | 45
POTEAU | 12.2 | +0.000 | +4.467 | 11>/E> | A0(?) | 45
POTEAU | 11.7 | -0.000 | +4.314 | 11>/E> | A0(?) | 45
POTEAU | 11.3 | +0.000 | +4.170 | 11>/E> | A0(?) | 45
POTEAU | 10.9 | -0.000 | +4.026 | 11>/E> | A0(?) | 45
2 x POTEAU | 10.2 | -0.000 | +3.736 | 11>/E> | A0(?) | 45
23 x POTEAU | 9.3 | +0.000 | +3.400 | 11>/E> | A0(?) | 45
POTEAU | 44.9 | -0.000 | +5.090 | 11>/D-E | A0(?) | 145
POTEAU | 8.5 | +0.000 | +3.095 | 11>/E> | A0(?) | 45
POTEAU | 8.5 | +0.000 | +3.116 | 11>/E> | A0(?) | 45
POTEAU | 8.5 | +0.000 | +3.137 | 11>/E> | A0(?) | 45
POTEAU | 8.7 | +0.000 | +3.158 | 11>/E> | A0(?) | 45
POTEAU | 8.7 | +0.000 | +3.179 | 11>/E> | A0(?) | 45
POTEAU | 8.7 | +0.000 | +3.200 | 11>/E> | A0(?) | 45
POTEAU | 8.7 | +0.000 | +3.221 | 11>/E> | A0(?) | 45
POTEAU | 9 | +0.000 | +3.243 | 11>/E> | A0(?) | 45
POTEAU | 9.3 | +0.000 | +3.401 | 11>/E> | A0(?) | 45
POTEAU | 9 | +0.000 | +3.262 | 11>/E> | A0(?) | 45
4 x POTEAU | 9.3 | -0.000 | +3.400 | 11>/E> | A0(?) | 45
20 x POTEAU | 13.9 | -0.000 | +5.090 | 11>/E> | A0(?) | 45
3 x POTEAU | 13.9 | -0.000 | +5.090 | 11>/E | A0(?) | 45
POTEAU | 13.9 | -0.000 | +5.090 | 11>/D-E | A0(?) | 45
7 x POTEAU | 9.7 | -0.000 | +3.525 | 11>/D-E | A0(?) | 45
POTEAU | 9.7 | -0.000 | +3.525 | 11>/D | A0(?) | 45
POTEAU | 10.7 | -0.000 | +3.956 | 11>/C-D | A0(?) | 45
POTEAU | 11.3 | -0.000 | +4.123 | 11>/C-D | A0(?) | 45
2 x POTEAU | 11.7 | -0.000 | +4.289 | 11>/C-D | A0(?) | 45
2 x POTEAU | 12.7 | +0.000 | +4.591 | 11>/C-D | A0(?) | 45
POTEAU | 12.7 | +0.000 | +4.609 | 11>/C-D | A0(?) | 45
POTEAU | 13.2 | -0.000 | +4.775 | 11>/C-D | A0(?) | 45
POTEAU | 13.4 | +0.000 | +4.941 | 11>/C | A0(?) | 45
PANNE | 64.2 | +4.213 | +4.474 | 11>/B-C | A0(?) | 75
PANNE | 64.2 | +3.675 | +3.936 | 11>/B-C | A0(?) | 75
PANNE | 64.2 | +3.944 | +4.205 | 11>/B-C | A0(?) | 75
PANNE | 64.2 | +4.483 | +4.744 | 11>/B-C | A0(?) | 75
PANNE | 112.1 | +4.579 | +4.792 | 10-11>/B-C | A0(?) | 75
PANNE | 112.1 | +4.310 | +4.522 | 10-11>/B-C | A0(?) | 75
PANNE | 112.1 | +4.040 | +4.253 | 10-11>/B-C | A0(?) | 75
PANNE | 112.1 | +3.771 | +3.984 | 10-11>/B-C | A0(?) | 75
2 x POTEAU | 13.9 | +0.000 | +5.063 | 11>/C | A0(?) | 45
2 x POTEAU | 13 | +0.000 | +4.761 | 11>/B-C | A0(?) | 45
POTEAU | 12.7 | -0.000 | +4.594 | 11>/B-C | A0(?) | 45
POTEAU | 12.2 | -0.000 | +4.428 | 11>/B-C | A0(?) | 45
POTEAU | 11.7 | +0.000 | +4.261 | 11>/B-C | A0(?) | 45
POTEAU | 11.1 | +0.000 | +4.095 | 11>/B-C | A0(?) | 45
4 x POTEAU | 10.7 | -0.000 | +3.916 | 10-11/B | A0(?) | 45
3 x POTEAU | 10.7 | -0.000 | +3.916 | 10/B | A0(?) | 45
POTEAU | 11.1 | +0.000 | +4.067 | 10/B-C | A0(?) | 45
POTEAU | 11.7 | +0.000 | +4.233 | 10/B-C | A0(?) | 45
POTEAU | 12.2 | +0.000 | +4.400 | 10/B-C | A0(?) | 45
POTEAU | 12.4 | +0.000 | +4.566 | 10/B-C | A0(?) | 45
POTEAU | 13 | -0.000 | +4.733 | 10/B-C | A0(?) | 45
POTEAU | 13.4 | +0.000 | +4.899 | 10/B-C | A0(?) | 45
POTEAU | 13.9 | -0.000 | +5.065 | 10/C | A0(?) | 45
POTEAU | 13.4 | +0.000 | +4.927 | 10/C | A0(?) | 45
POTEAU | 13 | +0.000 | +4.761 | 10/C-D | A0(?) | 45
POTEAU | 12.7 | +0.000 | +4.594 | 10/C-D | A0(?) | 45
POTEAU | 12.2 | -0.000 | +4.428 | 10/C-D | A0(?) | 45
POTEAU | 11.7 | +0.000 | +4.261 | 10/C-D | A0(?) | 45
POTEAU | 11.1 | +0.000 | +4.095 | 10/C-D | A0(?) | 45
2 x POTEAU | 10.7 | +0.000 | +3.915 | 10/C-D | A0(?) | 45
4 x POTEAU | 10.7 | +0.000 | +3.915 | 10-11/C-D | A0(?) | 45
POTEAU | 10.7 | +0.000 | +3.915 | 10/D | A0(?) | 45
POTEAU | 42.5 | -0.000 | +4.817 | 11/D-E | A0(?) | 145
2 x POTEAU | 42.5 | +0.000 | +4.817 | 11/E> | A0(?) | 145
POTEAU | 30.2 | +0.000 | +3.420 | 11/C-D | A0(?) | 145
FP | 58.8 | +3.359 | +3.559 | 10-11>/B | A0(?) | 40
6 x FP | 58.8 | +3.359 | +3.559 | 10-11>/B-C | A0(?) | 40
2 x FP | 58.8 | +3.359 | +3.559 | 10-11>/C | A0(?) | 40
6 x FP | 58.8 | +3.359 | +3.559 | 10-11>/C-D | A0(?) | 40
2 x POTEAU | 30.2 | -0.000 | +3.420 | 11>/C-D | A0(?) | 145
POUTRE | 76.4 | +2.251 | +2.680 | 11>/E> | A0(?) | 135
POUTRE | 56.3 | +2.870 | +3.270 | 11>/E> | A0(?) | 100
3 x POTEAU | 30 | +0.000 | +3.400 | 11>/E> | A0(?) | 145
POTEAU | 28.8 | -0.000 | +3.266 | 11>/E> | A0(?) | 145
2 x POTEAU | 28.9 | +0.000 | +3.270 | 11/E> | A0(?) | 145
POTEAU | 54.9 | +0.000 | +3.270 | 10/E> | A0(?) | 200
POUTRE | 130.6 | +2.790 | +3.290 | 11>/E> | A0(?) | 120
POUTRE | 115.1 | +2.790 | +3.290 | 11>/E> | A0(?) | 120
9 x POTEAU | 33 | +0.000 | +3.736 | 11>/E> | A0(?) | 145
17 x FP | 87.7 | +3.351 | +3.551 | 10-11>/E> | A0(?) | 40
CVT | 233.9 | +3.224 | +3.359 | 10-11>/B-C | A0(?) | 135
CVT | 233.9 | +3.224 | +3.359 | 10-11>/C-D | A0(?) | 135
POTEAU | 11.9 | +0.000 | +2.531 | 10/E> | Pt0(?) | 120
PANNE | 20.4 | +2.306 | +2.731 | 10-11/E> | A0(?) | 75
PANNE | 41 | +2.630 | +2.815 | 10-11/D-E> | A0(?) | 65
PANNE | 41 | +2.535 | +2.719 | 11/D-E> | A0(?) | 65
PANNE | 41 | +2.726 | +2.910 | 10/D-E> | A0(?) | 65
POUTRE | 126 | +2.200 | +3.027 | 11/D-E | A0(?) | 100
PANNE | 20.4 | +2.306 | +2.731 | 10-11/D-E | A0(?) | 75
CVT | 33.3 | +3.006 | +4.591 | 11>/E> | A0(?) | 135
CVT | 33.2 | +3.006 | +4.591 | 11>/E> | A0(?) | 135
CVT | 33.9 | +2.940 | +4.590 | 11>/E> | A0(?) | 135
CVT | 33.7 | +3.690 | +5.021 | 11>/B-C | A0(?) | 75
CVT | 34.1 | +3.675 | +5.021 | 11>/C-D | A0(?) | 75
POTEAU | 11.9 | +0.000 | +2.531 | 10/D-E | Pt0(?) | 120
PANNE | 53.5 | +2.716 | +2.925 | 11>/E> | A0(?) | 75
PANNE | 52.9 | +2.720 | +2.933 | 11>/E> | A0(?) | 75
PANNE | 52.8 | +2.720 | +2.933 | 11>/E> | A0(?) | 75
PANNE | 54.3 | +2.751 | +2.956 | 11>/E> | A0(?) | 75
POUTRE | 3427.8 | +0.000 | +3.643 | 9-10/E> | Po0(?) | 145 | Tekla Assemblages - Cast unit type: Coulé sur site; Poids ferraillage Elément béton: 0 kg
PANNE | 43.1 | +3.081 | +3.293 | 7-10/E> | A0(?) | 75
POUTRE | 6726.2 | +0.000 | +3.736 | 7-10/E> | Po0(?) | 145 | Tekla Assemblages - Cast unit type: Coulé sur site; Poids ferraillage Elément béton: 0 kg
POUTRE | 3427.8 | +0.000 | +3.643 | 7-8/E> | Po0(?) | 145 | Tekla Assemblages - Cast unit type: Coulé sur site; Poids ferraillage Elément béton: 0 kg
2 x CVT | 348.9 | +3.216 | +3.351 | 10-11>/E> | A0(?) | 135
CVT | 127.8 | +3.216 | +3.351 | 11>/E> | A0(?) | 135
CVT | 39.7 | +3.231 | +3.351 | 10-11>/E> | A0(?) | 120
2 x ARBA | 54 | +3.321 | +4.763 | 7-8/E> | A0(?) | 90
2 x CVT | 45.3 | +3.902 | +4.127 | 7-8/E> | A0(?) | 90
POUTRE | 6.4 | +3.845 | +4.596 | 11>/C | A0(?) | 90
2 x CVT | 22.2 | +2.097 | +4.036 | 11>/C-D | A0(?) | 90
2 x POTEAU | 46.6 | +0.000 | +3.679 | 11>/C-D | A0(?) | 90
2 x POTEAU | 46.6 | +0.000 | +3.679 | 11>/B-C | A0(?) | 90
POUTRE | 5 | +3.899 | +4.486 | 7-8/E> | A0(?) | 90
4 x POTEAU | 39 | +0.000 | +3.648 | 7-8/E> | A0(?) | 90
CVT | 146 | +4.591 | +4.726 | 11/D-E> | A0(?) | 135
CVT | 115.5 | +4.591 | +4.726 | 11>/D-E | A0(?) | 135
CVT | 148.4 | +4.591 | +4.726 | 11>/D-E> | A0(?) | 135
CVT | 40.5 | +2.807 | +4.701 | 11>/D-E> | A0(?) | 135
CVT | 53.5 | +2.789 | +4.709 | 11>/D-E> | A0(?) | 135
CVT | 47.8 | +2.790 | +4.563 | 11>/D-E> | A0(?) | 135
CVT | 40.1 | +2.866 | +4.721 | 11>/E> | A0(?) | 135
CVT | 49.2 | +2.884 | +4.705 | 11>/E> | A0(?) | 135
CVT | 52.5 | +2.884 | +4.728 | 11>/E> | A0(?) | 135
CVT | 40.3 | +2.996 | +4.668 | 11>/E> | A0(?) | 135
CVT | 30.8 | +3.050 | +4.649 | 11>/E> | A0(?) | 135
CVT | 37.2 | +2.853 | +4.665 | 11>/E> | A0(?) | 135
CVT | 41 | +4.591 | +4.726 | 11>/E> | A0(?) | 135
5 x CVT | 60.6 | +3.231 | +3.351 | 11>/E> | A0(?) | 120
CVT | 153.2 | +3.216 | +3.351 | 10/E> | A0(?) | 135
CVT | 107.7 | +3.224 | +3.359 | 10/B-D | A0(?) | 135
CVT | 107.7 | +3.224 | +3.359 | 11>/B-D | A0(?) | 135
CVT | 50.5 | +3.249 | +3.369 | 11>/B-D | A0(?) | 120
2 x CVT | 50.5 | +3.239 | +3.359 | 11>/B-D | A0(?) | 120
5 x POTEAU | 33 | -0.000 | +3.736 | 11>/B | A0(?) | 145
PANNE | 84 | +3.728 | +3.940 | 10-11>/E> | A0(?) | 75
PANNE | 84 | +4.010 | +4.222 | 10-11>/E> | A0(?) | 75
PANNE | 84 | +4.293 | +4.505 | 10-11>/E> | A0(?) | 75
PANNE | 84 | +4.575 | +4.787 | 10-11>/E> | A0(?) | 75
PANNE | 166.3 | +4.866 | +5.066 | 10-11>/E> | A0(?) | 75
PANNE | 166.3 | +4.584 | +4.796 | 10-11>/E> | A0(?) | 75
PANNE | 166.3 | +4.310 | +4.522 | 10-11>/E> | A0(?) | 75
PANNE | 166.3 | +4.036 | +4.248 | 10-11>/E> | A0(?) | 75
PANNE | 166.3 | +3.763 | +3.975 | 10-11>/E> | A0(?) | 75
MUR | 0 | +0.000 | +3.916 | 10-11>/E> | Po0(?) | 145
CVT | 75.3 | +4.591 | +4.726 | 11>/E> | A0(?) | 135
CVT | 41.8 | +2.941 | +4.723 | 11>/E> | A0(?) | 135
4 x POTEAU | 38.5 | +0.000 | +3.270 | 11>/E> | A0(?) | 90
2 x PLAT | 338.6 | +3.359 | +4.866 | 11>/B-D | G0(?) | 100
PLAT | 341 | +3.359 | +4.866 | 11>/B-D | G0(?) | 100
5 x PLAT | 400.2 | +3.351 | +4.866 | 11>/E> | G0(?) | 100
CVT | 55.2 | +3.289 | +4.762 | 11>/B-C | A0(?) | 90
CVT | 53.7 | +3.322 | +4.762 | 11>/C-D | A0(?) | 90
CVT | 38.7 | -0.040 | +3.704 | 11>/B | A0(?) | 145
CVT | 39 | -0.040 | +3.704 | 11>/B | A0(?) | 145
CVT | 21.9 | +3.591 | +3.736 | 11>/B | A0(?) | 145
CVT | 22.2 | +3.591 | +3.736 | 11>/B | A0(?) | 145
POTEAU | 33 | +0.000 | +3.736 | 11>/B | A0(?) | 145
2 x CVT | 31.4 | +2.265 | +3.731 | 11>/E> | A0(?) | 145
2 x CVT | 24 | -0.037 | +2.370 | 11>/E> | A0(?) | 145
CVT | 22.5 | -0.024 | +2.429 | 11>/E> | A0(?) | 145
2 x CVT | 29.7 | +2.260 | +2.405 | 11>/E> | A0(?) | 145
2 x CVT | 30.4 | +3.591 | +3.736 | 11>/E> | A0(?) | 145
4 x POTEAU | 21.2 | +0.000 | +2.405 | 11>/E> | A0(?) | 145
CVT | 22.2 | -0.021 | +2.427 | 11>/E> | A0(?) | 145
CVT | 12.4 | +3.838 | +5.001 | 9-10/E> | A0(?) | 80
CVT | 13 | +3.804 | +5.001 | 9-10/E> | A0(?) | 80
CVT | 6.9 | +3.795 | +4.164 | 7-9/E> | A0(?) | 80
CVT | 7.2 | +3.795 | +4.164 | 9-10/E> | A0(?) | 80
CVT | 13 | +3.804 | +5.001 | 8-9/E> | A0(?) | 80
CVT | 6.9 | +3.830 | +4.190 | 7-9/E> | A0(?) | 80
CVT | 7.2 | +3.821 | +4.190 | 9-10/E> | A0(?) | 80
CVT | 12.4 | +3.838 | +5.001 | 8-9/E> | A0(?) | 80
2 x CVT | 7.8 | +3.781 | +4.147 | 11>/C-D | A0(?) | 80
CVT | 10.7 | +3.791 | +4.935 | 11>/C-D | A0(?) | 80
2 x CVT | 7.5 | +3.805 | +4.070 | 11>/B-C | A0(?) | 80
CVT | 10.5 | +3.816 | +4.935 | 11>/B-C | A0(?) | 80
PANNE | 64.2 | +4.213 | +4.474 | 11>/C-D | A0(?) | 75
PANNE | 64.2 | +3.675 | +3.936 | 11>/C-D | A0(?) | 75
PANNE | 64.2 | +3.944 | +4.205 | 11>/C-D | A0(?) | 75
PANNE | 64.2 | +4.483 | +4.744 | 11>/C-D | A0(?) | 75
PANNE | 64.2 | +4.762 | +5.012 | 11>/C | A0(?) | 75
2 x ENTRETOISE | 9 | +3.388 | +3.864 | 11>/E> | E0(?) | 80
2 x ENTRETOISE | 4.1 | +3.776 | +4.654 | 11>/E> | E0(?) | 80
2 x ENTRETOISE | 5.6 | +3.389 | +3.863 | 11>/E> | E0(?) | 80
3 x ENTRETOISE | 3.5 | +3.767 | +4.610 | 11>/E> | E0(?) | 80
4 x ENTRETOISE | 4.6 | +3.400 | +3.854 | 11>/E> | E0(?) | 80
2 x ENTRETOISE | 4.5 | +3.400 | +3.854 | 11>/E> | E0(?) | 80
2 x ENTRETOISE | 4.6 | +3.280 | +3.835 | 11>/E> | E0(?) | 80
2 x ENTRETOISE | 4.1 | +3.295 | +3.820 | 11>/E> | E0(?) | 80
ENTRETOISE | 6.4 | +3.735 | +4.725 | 11>/E> | E0(?) | 80
2 x ENTRETOISE | 6.2 | +3.750 | +4.725 | 11>/E> | E0(?) | 80
2 x ENTRETOISE | 7.2 | +3.278 | +3.838 | 11>/E> | E0(?) | 80
ENTRETOISE | 4.1 | +3.288 | +3.817 | 11>/E> | E0(?) | 80
ENTRETOISE | 4.5 | +3.288 | +3.817 | 11>/E> | E0(?) | 80
3 x ENTRETOISE | 6.4 | +3.733 | +4.732 | 11>/D-E> | E0(?) | 80
2 x ENTRETOISE | 4.5 | +3.287 | +3.818 | 11>/E> | E0(?) | 80
ENTRETOISE | 6.9 | +3.285 | +3.821 | 11>/E> | E0(?) | 80
ENTRETOISE | 7.2 | +3.285 | +3.821 | 11>/E> | E0(?) | 80
3 x POUTRE | 95.8 | +2.830 | +3.337 | 11>/D-E | A0(?) | 140
POUTRE | 12.2 | +2.870 | +4.811 | 11/E> | A0(?) | 75
8 x POUTRE | 11.9 | +2.870 | +4.777 | 11>/E> | A0(?) | 75
2 x POUTRE | 13.4 | +2.870 | +3.070 | 11>/E> | A0(?) | 75
2 x POUTRE | 13.4 | +2.877 | +3.077 | 11>/E> | A0(?) | 75
POUTRE | 49.4 | +3.047 | +4.777 | 11>/E> | A0(?) | 120
2 x POUTRE | 11.9 | +2.870 | +3.070 | 11>/E> | A0(?) | 75
2 x POUTRE | 11.9 | +2.877 | +3.077 | 11>/E> | A0(?) | 75
POUTRE | 51.7 | +2.981 | +4.777 | 11>/E> | A0(?) | 120
2 x POUTRE | 12.2 | +2.870 | +4.817 | 11>/E> | A0(?) | 75
2 x CVT | 84 | +2.825 | +3.185 | 11/E> | A0(?) | 90
2 x CVT | 85.5 | +2.825 | +3.185 | 11>/E> | A0(?) | 90
2 x POUTRE | 12.2 | +2.870 | +4.811 | 11>/D-E | A0(?) | 75
4 x POUTRE | 13.4 | +2.870 | +5.020 | 11>/D-E | A0(?) | 75
2 x POUTRE | 11.7 | +2.870 | +4.721 | 11>/E | A0(?) | 75
2 x POUTRE | 13 | +2.870 | +4.921 | 11>/E> | A0(?) | 75
2 x POUTRE | 28.9 | +2.870 | +3.070 | 11>/E> | A0(?) | 75
2 x POUTRE | 12.7 | +2.870 | +4.867 | 11>/E> | A0(?) | 75
4 x POUTRE | 13.4 | +2.870 | +5.020 | 11>/E> | A0(?) | 75
POUTRE | 108.6 | +2.751 | +4.800 | 11>/D-E> | A0(?) | 120
POUTRE | 121.9 | +2.716 | +4.850 | 11>/D-E> | A0(?) | 120
POUTRE | 120.7 | +2.716 | +4.830 | 11>/E> | A0(?) | 120
POUTRE | 121.7 | +2.751 | +4.974 | 11>/E> | A0(?) | 120
4 x POUTRE | 15.9 | +2.870 | +3.070 | 11>/E> | A0(?) | 75
ENTRETOISE | 6.2 | +3.796 | +4.163 | 10-11/E> | E0(?) | 80
ENTRETOISE | 6.2 | +3.796 | +4.163 | 10-11>/E> | E0(?) | 80
2 x ENTRETOISE | 7.5 | +3.796 | +4.163 | 11>/E> | E0(?) | 80
2 x ENTRETOISE | 6.7 | +3.795 | +4.163 | 11>/E> | E0(?) | 80
ENTRETOISE | 5 | +3.796 | +4.163 | 11>/E> | E0(?) | 80
ENTRETOISE | 5.1 | +3.796 | +4.163 | 11>/E> | E0(?) | 80
ENTRETOISE | 6.4 | +3.821 | +4.164 | 11>/E> | E0(?) | 80
ENTRETOISE | 6.7 | +3.821 | +4.164 | 11>/E> | E0(?) | 80
2 x ENTRETOISE | 6.4 | +3.822 | +4.163 | 11>/E> | E0(?) | 80
5 x ENTRETOISE | 9.7 | +4.077 | +5.001 | 11>/E> | E0(?) | 80
ENTRETOISE | 9.7 | +4.077 | +5.001 | 10-11/E> | E0(?) | 80
2 x POUTRE | 129.1 | +2.655 | +3.262 | 11>/E> | A0(?) | 135
POUTRE | 64.4 | +2.660 | +3.180 | 11>/E> | A0(?) | 135
POTEAU | 47.4 | -0.000 | +2.820 | 11>/E> | A0(?) | 200
POUTRE | 49.8 | +2.688 | +3.180 | 11>/E> | A0(?) | 135
4 x POUTRE | 93.3 | +2.688 | +3.264 | 11>/E> | A0(?) | 135
PANNE | 82.3 | +4.575 | +4.787 | 11>/E> | A0(?) | 75
PANNE | 82.3 | +4.010 | +4.222 | 11>/E> | A0(?) | 75
PANNE | 82.3 | +3.728 | +3.940 | 11>/E> | A0(?) | 75
PANNE | 82.3 | +4.293 | +4.505 | 11>/E> | A0(?) | 75
POUTRE | 96.1 | +2.688 | +3.269 | 11>/E> | A0(?) | 135
4 x POUTRE | 25.2 | +2.870 | +3.070 | 11>/D-E> | A0(?) | 75
2 x POUTRE | 111.4 | +2.720 | +5.020 | 11>/D-E> | A0(?) | 120
4 x POUTRE | 25.2 | +2.870 | +3.070 | 11>/E> | A0(?) | 75
2 x POUTRE | 111.4 | +2.720 | +5.020 | 11>/E> | A0(?) | 120
ENTRETOISE | 5.6 | +3.844 | +4.118 | 11>/B-C | E0(?) | 80
3 x ENTRETOISE | 6 | +3.844 | +4.118 | 11>/B-C | E0(?) | 80
3 x ENTRETOISE | 9 | +4.031 | +5.000 | 11>/B-C | E0(?) | 80
ENTRETOISE | 6.2 | +3.844 | +4.117 | 10-11>/B-C | E0(?) | 80
ENTRETOISE | 6.2 | +3.845 | +4.117 | 10-11/B-C | E0(?) | 80
ENTRETOISE | 9 | +4.031 | +5.000 | 10-11/B-C | E0(?) | 80
2 x ENTRETOISE | 6.4 | +3.844 | +4.118 | 11>/B-C | E0(?) | 80
ENTRETOISE | 6.2 | +3.830 | +4.195 | 11>/C-D | E0(?) | 80
3 x ENTRETOISE | 6.4 | +3.829 | +4.195 | 11>/C-D | E0(?) | 80
3 x ENTRETOISE | 8.3 | +4.108 | +5.000 | 11>/C-D | E0(?) | 80
ENTRETOISE | 6.4 | +3.830 | +4.195 | 10-11>/C-D | E0(?) | 80
ENTRETOISE | 6.4 | +3.830 | +4.195 | 10-11/C-D | E0(?) | 80
ENTRETOISE | 8.3 | +4.108 | +5.000 | 10-11/C-D | E0(?) | 80
2 x ENTRETOISE | 6.9 | +3.829 | +4.195 | 11>/C-D | E0(?) | 80
ENTRETOISE | 6.2 | +3.822 | +4.189 | 10-11/E> | E0(?) | 80
ENTRETOISE | 6.2 | +3.822 | +4.189 | 10-11>/E> | E0(?) | 80
2 x ENTRETOISE | 7.5 | +3.822 | +4.189 | 11>/E> | E0(?) | 80
3 x ENTRETOISE | 6.7 | +3.821 | +4.190 | 11>/E> | E0(?) | 80
ENTRETOISE | 5 | +3.822 | +4.189 | 11>/E> | E0(?) | 80
ENTRETOISE | 5.1 | +3.822 | +4.189 | 11>/E> | E0(?) | 80
ENTRETOISE | 6.9 | +3.821 | +4.190 | 11>/E> | E0(?) | 80
2 x ENTRETOISE | 6.7 | +3.822 | +4.189 | 11>/E> | E0(?) | 80
5 x ENTRETOISE | 9.3 | +4.103 | +5.001 | 11>/E> | E0(?) | 80
ENTRETOISE | 9.3 | +4.103 | +5.001 | 10-11/E> | E0(?) | 80
POTEAU | 46.5 | -0.000 | +3.420 | 11>/C-D | A0(?) | 180
POTEAU | 44.8 | -0.000 | +3.290 | 11>/D-E | A0(?) | 180
PANNE | 68.1 | +3.913 | +4.222 | 7-10/E> | A0(?) | 75
PANNE | 68.1 | +4.195 | +4.505 | 7-10/E> | A0(?) | 75
PANNE | 68.1 | +4.478 | +4.787 | 7-10/E> | A0(?) | 75
PANNE | 68.1 | +3.939 | +4.248 | 7-10/E> | A0(?) | 75
PANNE | 68.1 | +4.213 | +4.522 | 7-10/E> | A0(?) | 75
PANNE | 68.1 | +4.487 | +4.796 | 7-10/E> | A0(?) | 75
PANNE | 68.1 | +3.631 | +3.940 | 7-10/E> | A0(?) | 75
PANNE | 68.1 | +4.766 | +5.066 | 7-10/E> | A0(?) | 75
PANNE | 68.1 | +3.665 | +3.975 | 7-10/E> | A0(?) | 75
MUR | 0 | +0.000 | +3.425 | 10/E> | Po0(?) | 145
PANNE | 151 | +2.900 | +3.203 | 11>/E> | A0(?) | 75
PANNE | 198.3 | +2.845 | +3.148 | 10-11>/E> | A0(?) | 75
PANNE | 138.7 | +2.956 | +3.259 | 11>/E> | A0(?) | 75
PANNE | 65.4 | +2.914 | +3.216 | 11>/E> | A0(?) | 75
PANNE | 74.1 | +2.872 | +3.175 | 11>/E> | A0(?) | 75
PANNE | 82.8 | +2.830 | +3.133 | 11>/E> | A0(?) | 75
PANNE | 57.2 | +2.956 | +3.258 | 11>/E> | A0(?) | 75
POUTRE | 146.2 | +2.688 | +3.257 | 11>/E> | A0(?) | 135
PANNE | 91.5 | +2.788 | +3.091 | 11>/E> | A0(?) | 75
PANNE | 213.2 | +2.789 | +3.092 | 10-11>/E> | A0(?) | 75
MUR | 0 | +0.000 | +5.000 | 11/D-E> | Po0(?) | 145
MUR | 0 | -0.000 | +5.090 | 11>/D-E> | Po0(?) | 145
MUR | 0 | -0.000 | +3.525 | 11>/D-E | Po0(?) | 145
PANNE | 97.7 | +3.620 | +3.902 | 11>/E> | A0(?) | 75
PANNE | 97.8 | +3.623 | +3.905 | 11>/E> | A0(?) | 75
PANNE | 122.2 | +3.864 | +4.129 | 11>/E> | A0(?) | 75
PANNE | 123.2 | +3.874 | +4.147 | 11>/E> | A0(?) | 75
PANNE | 99 | +3.265 | +3.538 | 11>/E> | A0(?) | 75
PANNE | 148.4 | +4.482 | +4.756 | 11>/E> | A0(?) | 75
PANNE | 109.5 | +4.081 | +4.363 | 11>/E> | A0(?) | 75
PANNE | 86.1 | +3.165 | +3.447 | 11>/E> | A0(?) | 75
PANNE | 109.5 | +4.083 | +4.365 | 11>/E> | A0(?) | 75
PANNE | 85.9 | +3.157 | +3.439 | 11>/E> | A0(?) | 75
2 x POUTRE | 16.5 | +1.924 | +3.046 | 11>/E> | A0(?) | 120
POTEAU | 45.7 | +0.000 | +2.720 | 11>/E> | A0(?) | 200
POTEAU | 37 | +0.000 | +2.720 | 11>/E> | A0(?) | 180
POTEAU | 55.3 | -0.000 | +3.290 | 11>/E> | A0(?) | 200
PANNE | 121.1 | +4.539 | +4.821 | 11>/E> | A0(?) | 75
POUTRE | 12.2 | +2.870 | +4.811 | 11>/E> | A0(?) | 75
2 x POUTRE | 29.5 | +2.870 | +3.070 | 11>/E> | A0(?) | 75
CVT | 104.6 | +2.870 | +3.140 | 11>/E> | A0(?) | 90
24 x POUTRE | 19.8 | +0.000 | +3.140 | 11>/E> | A0(?) | 75
POUTRE | 20.8 | +0.000 | +3.300 | 11>/E> | A0(?) | 75
CVT | 102.9 | +2.870 | +3.140 | 11>/E> | A0(?) | 90
CVT | 110.2 | +2.870 | +3.140 | 11>/E> | A0(?) | 90
PANNE | 99.2 | +3.280 | +3.545 | 11>/E> | A0(?) | 75
PANNE | 146.6 | +4.448 | +4.713 | 11>/E> | A0(?) | 75
PANNE | 121.3 | +4.546 | +4.828 | 11>/D-E | A0(?) | 75
PANNE | 137.8 | +2.989 | +3.291 | 11>/D-E | A0(?) | 75
PANNE | 137.8 | +2.954 | +3.256 | 11>/D-E | A0(?) | 75
PANNE | 137.8 | +3.024 | +3.326 | 11>/D-E | A0(?) | 75
PANNE | 137.8 | +2.919 | +3.221 | 11>/D | A0(?) | 75
PANNE | 112.1 | +4.579 | +4.792 | 10-11>/C-D | A0(?) | 75
PANNE | 112.1 | +4.310 | +4.522 | 10-11>/C-D | A0(?) | 75
PANNE | 112.1 | +4.040 | +4.253 | 10-11>/C-D | A0(?) | 75
PANNE | 112.1 | +3.771 | +3.984 | 10-11>/C-D | A0(?) | 75
PANNE | 112.1 | +4.866 | +5.066 | 10-11>/C | A0(?) | 75
CVT | 51 | +3.216 | +3.351 | 11>/E> | A0(?) | 135
CVT | 52.3 | +3.216 | +3.352 | 11>/E> | A0(?) | 135
CVT | 44.9 | +3.216 | +3.352 | 11>/E> | A0(?) | 135
CVT | 52.5 | +3.216 | +3.351 | 11>/E> | A0(?) | 135
CVT | 56.4 | +3.216 | +3.351 | 11>/E> | A0(?) | 135
CVT | 49 | +3.216 | +3.351 | 10-11>/E> | A0(?) | 135
POTEAU | 44.5 | +0.000 | +3.270 | 11>/E> | A0(?) | 180
POTEAU | 54.9 | +0.000 | +3.270 | 11>/E> | A0(?) | 200
CVT | 10.7 | +2.955 | +3.055 | 11>/E> | A0(?) | 100
CVT | 45.6 | +3.224 | +3.359 | 11>/B-C | A0(?) | 135
CVT | 46.8 | +3.224 | +3.359 | 11>/B-C | A0(?) | 135
CVT | 48.8 | +3.224 | +3.359 | 11>/B-C | A0(?) | 135
CVT | 47.1 | +3.224 | +3.359 | 10-11>/B-C | A0(?) | 135
CVT | 139.1 | +3.224 | +3.359 | 10-11>/C | A0(?) | 135
CVT | 208.1 | +3.216 | +3.351 | 10-11>/E> | A0(?) | 135
POUTRE | 58.1 | +3.083 | +4.872 | 11>/E> | A0(?) | 120
2 x POUTRE | 28.9 | +2.870 | +3.070 | 11>/D-E> | A0(?) | 75
POUTRE | 1133.9 | +2.770 | +3.702 | 10-11>/E> | A0(?) | 120
POUTRE | 26.3 | +2.870 | +3.070 | 11>/E> | A0(?) | 75
POUTRE | 29.5 | +2.870 | +3.070 | 11>/D-E> | A0(?) | 75
MUR | 0 | +0.000 | +3.267 | 11>/E> | Po0(?) | 145
2 x MUR | 0 | +0.000 | +3.400 | 11>/E> | Po0(?) | 145
POUTRE | 4884.4 | +0.000 | +3.266 | 11>/E> | Po0(?) | 145 | Tekla Assemblages - Cast unit type: Coulé sur site; Poids ferraillage Elément béton: 0 kg
POUTRE | 3513.8 | +0.000 | +4.640 | 11>/E> | Po0(?) | 145 | Tekla Assemblages - Cast unit type: Coulé sur site; Poids ferraillage Elément béton: 0 kg
POUTRE | 7586 | +0.000 | +5.000 | 11/E> | Po0(?) | 145 | Tekla Assemblages - Cast unit type: Coulé sur site; Poids ferraillage Elément béton: 0 kg
POUTRE | 133 | +2.825 | +3.425 | 11/E> | A0(?) | 100
POUTRE | 132.8 | +2.790 | +3.290 | 11>/E> | A0(?) | 120
MUR | 0 | +0.000 | +4.640 | 11>/E> | Po0(?) | 145
MUR | 0 | +0.000 | +3.735 | 11/C-E | Po0(?) | 145
MUR | 0 | +0.000 | +3.290 | 11>/D-E | Po0(?) | 145
MUR | 0 | +0.000 | +3.425 | 11/E> | Po0(?) | 145
MUR | 0 | +0.000 | +3.425 | 10-11/E> | Po0(?) | 145
MUR | 0 | +0.000 | +5.072 | 10/E> | Po0(?) | 145
MUR | 0 | +0.000 | +5.072 | 11>/E> | Po0(?) | 145
MUR | 0 | -0.000 | +5.073 | 11>/B-D | Po0(?) | 145
MUR | 0 | +0.000 | +3.916 | 10-11>/B | Po0(?) | 145
MUR | 0 | +0.000 | +5.073 | 10/B-D | Po0(?) | 145
MUR | 0 | +0.000 | +3.915 | 11>/C-D | Po0(?) | 145
POUTRE | 222.3 | +2.790 | +3.290 | 11>/D-E | A0(?) | 120
POUTRE | 365.4 | +2.848 | +3.748 | 11>/C-D | A0(?) | 120

# IfcPlate: PL100*1507 (3)
In: Undefined
Description: PL100*1507; Material: TIMBER/GL24h - BLC
Tekla Commun - Niveau bas: +3.359; Niveau haut: +4.866; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 1; Classe: 8; Matériau: GL24h - BLC; Profil: PL100*1507; Nom: PLAT
Tekla Quantités - Volume: 0.8 m3; Surface supérieure totale: 0 m2; Surface par tonne: 50.6 m2; Hauteur: 1507.1 mm; Largeur: 100 mm
Pset_PlateCommon - Support de charge: no; Réference: G0(?)
BaseQuantities - Width: 1507.13 mm; CrossSectionArea: 0.01 m2
Name | Poids (kg) | Surface nette (m2) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLAT | 338.6 | 17.1 | 8200.3 | 17.1354 | 12.3589 | 0.769519
PLAT | 341 | 17.3 | 8345.3 | 17.2684 | 12.5774 | 0.774894

# IfcPlate: PL100*1515 (5)
In: Undefined
Description: PL100*1515; Material: TIMBER/GL24h - BLC
Pset_PlateCommon - Support de charge: no; Réference: G0(?)
Tekla Commun - Niveau bas: +3.351; Niveau haut: +4.866; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 1; Classe: 8; Matériau: GL24h - BLC; Profil: PL100*1515; Nom: PLAT
Tekla Quantités - Poids: 400.2 kg; Volume: 0.8 m3; Surface supérieure totale: 0 m2; Surface par tonne: 50.6 m2; Surface nette: 20.3 m2; Hauteur: 1514.8 mm; Largeur: 100 mm; Longueur: 9848.5 mm
BaseQuantities - Width: 1514.84 mm; NetArea: 20.2567 m2; GrossArea: 14.9189 m2; CrossSectionArea: 0.01 m2; NetVolume: 0.909623 m3; GrossVolume: 0.909623 m3
